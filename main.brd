File: main.brd (EAGLE design)
At the start: 130 x 34 mm, 169 parts, among them CN1 DC-012A-D010, CN2 JST GH 6P V-TH, CN3 5.8ZSPT, CN4 FFC 8P 0.5mm, CN5 MC-118LS-H100, CN6 JST GH 6P V-TH, CN8 FFC 8P 0.5mm, Q1 GSFP0449, Q6 IRLML6244, U1 T20F169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

Commit message: Bidirectional motor controller added
Parts:
- removed D13: B360A-13-F, DIODES:DO214AC
- removed Q6: IRLML6244, TRANSISTORs:SOT23-3
- added C81: 0.1uF 50V, c_0603:0603
- added R27: 100R, r_0402:0402
- added R28: 10k, r_0402:0402
- added U14: AS4950, ICs:SO8_PP
- C33, C35, C36, C37: device c_0603:0603 -> c_0402:0402
- D3: value 12V BI TVS -> 18V BI TVS
- moved R68 7.79 mm to (48.9, -0.88), flipped to the bottom, turned to 270 degrees
- moved C68 7.14 mm to (45.1, -9.00), turned to 270 degrees
- moved CN1 2.50 mm to (57.5, -1.00)
- moved C22 2.30 mm to (-50.5, 12.6)
- moved R10 2.30 mm to (-48.0, 2.88)
- moved R7 2.30 mm to (-50.5, 2.88)
- moved R8 2.30 mm to (-49.2, 2.88)
- moved R9 2.30 mm to (-46.8, 2.88)
- moved U3 2.30 mm to (-48.6, 7.75)
- moved R22 2.24 mm to (-1.62, 15.1), turned to 0 degrees
- moved C33 0.50 mm to (-3.75, 12.0)
- moved C35 0.50 mm to (4.75, 12.2)
- moved C36 0.50 mm to (4.12, -10.6)
- moved C37 0.50 mm to (-4.38, -10.9)
- moved C67 0.38 mm to (-23.8, 5.62), turned to 90 degrees
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Connections:
- removed net MTR_CONT_PWM: Q6.1, R68.2
- removed net N$57: C68.1, CN6.2, D13.A, Q6.2
- new net MTR_CONT_N: R68.2, U1.F13, U14.2
- new net MTR_CONT_P: R28.2, U1.E13, U14.3
- new net MTR_OUT_N: C81.1, CN6.1, U14.8
- new net MTR_OUT_P: C81.2, CN6.2, U14.6
- net GND: now also C68.1, R28.1, U14.1, U14.7, U14.PAD; no longer Q6.3
- net LED_PWM_CONT: now also U1.G11; no longer U1.F12
- net MTR_SENSE_A: now also U1.F12; no longer U1.E13
- net MTR_SENSE_B: now also U1.G12; no longer U1.F13
- net PWR_BUS_UNREG: now also U14.5; no longer CN6.1, D13.K
- net RAM_CLK_N: now also R27.1
- net RAM_CLK_P: now also R27.2
Routing:
- net MTR_CONT_N: track 0.00 -> 78.7 mm, vias 0 -> 2
- net MTR_CONT_P: track 0.00 -> 77.2 mm, vias 0 -> 2
- net N$57: track 9.52 -> 0.00 mm
- net LED_PWM_CONT: track 58.6 -> 51.6 mm
- net MTR_OUT_P: track 0.00 -> 6.06 mm
- net MTR_OUT_N: track 0.00 -> 5.96 mm
- net PWR_BUS_UNREG: track 29.4 -> 24.0 mm
- net PWR_SYS_3V3: track 90.2 -> 87.6 mm
- net N$45: track 16.5 -> 14.0 mm
- net N$43: track 18.1 -> 15.7 mm
- net N$44: track 17.2 -> 14.7 mm
- net MTR_CONT_PWM: track 1.43 -> 0.00 mm
- net PROC_NRST: track 32.4 -> 31.2 mm
- net RAM_CLK_P: track 8.72 -> 9.70 mm, vias 1 -> 2
- net RAM_CLK_N: track 7.46 -> 8.44 mm, vias 1 -> 2
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Other:
- board text added: "Soke Eng. knokke 3.0.0 2024.04.01"

Commit message: MIPI length matched
Routing:
- net AR_MIPI_D1_N: track 14.7 -> 18.1 mm
- net AR_MIPI_D1_P: track 14.9 -> 18.0 mm
- net AR_MIPI_D0_N: track 16.3 -> 18.1 mm
- net AR_MIPI_D0_P: track 16.2 -> 18.0 mm
- net AR_MIPI_D2_P: track 16.3 -> 17.9 mm
- net AR_MIPI_D2_N: track 16.5 -> 18.0 mm
- net AR_MIPI_CLK_P: track 16.5 -> 17.9 mm
- net AR_MIPI_CLK_N: track 17.0 -> 18.1 mm
- net AR_MIPI_D3_N: track 18.5 -> 18.0 mm

Commit message: ESP32 added with architecture implemented. First attempt.
Parts:
- removed CN4: FFC 8P 0.5mm, CONNECTORs:HC-FPC-05-09-8RLTAG
- removed R137, R138, R142, R144, R73: 10k, r_0402:0402
- removed U25: SCHMITT, ICs:SOT23-5
- added C162, C163, C86: 0.1uF 10V, c_0402:0402
- added C164: 10uF 10V, CAPACITORS:0603
- added C83, C85: 0.1uF 16V, c_0402:0402
- added C84: 10uF 6.3V, c_0402:0402
- added D10, D8: B360A-13-F, DIODES:DO214AC
- added D12, D13, D14, D15: BAT54S-7-F, DIODES:SOT23-3-BAT54S
- added D5, D6, D7: RED LED, OPTO:0603_POLAR
- added FB1: 150R 100MHz, INDUCTORS:1206
- added Q2, Q3: MMBT3904, TRANSISTORs:SOT23-3
- added R129, R31, R87, R89, R90: 10k, r_0402:0402
- added R29, R33: 22R, r_0402:0402
- added R32: 100k, r_0402:0402
- added R59, R79, R80: 2.2k, r_0402:0402
- added U15: ESP32, ICs:ESP32-WROOM-32D
- added U16: PI4ULS3V204ZBEX, ICs:TQFN14
- C61: value 0.1uF 16V -> 0.1uF 50V; device c_0402:0402 -> c_0603:0603
- C66: value 0.1uF 16V -> 0.1uF 10V
- R13, R16: value 10k -> 22R
- R2, R4: value 1.5k -> 2.2k
- R3: value 10R -> 22R
- U4: value W25Q128JV -> SCHMITT; device ICs:SO8-208MIL -> ICs:SOT23-5
- moved R13 78.8 mm to (43.2, -9.88), turned to 90 degrees
- moved U4 74.5 mm to (38.6, -1.88), flipped to the bottom
- moved R16 74.1 mm to (37.5, -9.88), turned to 90 degrees
- moved R14 71.3 mm to (38.1, -4.62), turned to 180 degrees
- moved R11 64.3 mm to (23.9, 8.00), flipped to the bottom
- moved R12 53.1 mm to (23.9, 6.00), flipped to the bottom
- moved D9 39.8 mm to (69.4, 4.12)
- moved R58 34.0 mm to (68.4, 5.75), turned to 270 degrees
- moved C66 33.7 mm to (8.25, 5.38), turned to 270 degrees
- moved C44 29.2 mm to (36.6, -9.75), turned to 90 degrees
- moved C45 28.9 mm to (38.4, -9.75), turned to 90 degrees
- moved C46 28.8 mm to (40.1, -9.75), turned to 90 degrees
- moved CN3 28.4 mm to (60.0, 7.00)
- moved R18 27.6 mm to (42.4, -8.75), turned to 180 degrees
- moved C48 26.2 mm to (42.4, -7.75), turned to 180 degrees
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Connections:
- removed net FLS_NHOLD: R138.1, U4.7
- removed net N$38: R137.1, U4.3
- removed net PROC_JTAG_TCK: CN4.4, R13.1, U1.N3
- removed net PROC_JTAG_TDI: CN4.5, U1.M5
- removed net PROC_JTAG_TDO: CN4.2, R14.1, U1.N2
- removed net PROC_JTAG_TMS: CN4.3, U1.F2
- removed net PROC_NRST: CN4.7, R16.1, U1.G3
- removed net USB_VBUS: CN5.A4, CN5.A9, CN5.B4, CN5.B9, U2.5
- new net ESP_EN: C162.2, Q2.2, R87.1, U15.3
- new net ESP_I2C_SCL: U15.9, U16.10
- new net ESP_I2C_SDA: U15.8, U16.11
- new net ESP_IO0: Q3.2, R29.1, R89.1, U15.25
- new net ESP_IO5: R129.1, U15.29
- new net ESP_UART_NDTR: Q3.3, R11.2, U6.43
- new net ESP_UART_NRTS: Q2.3, R12.2, U6.40
- new net ESP_UART_RX: R90.1, U15.34, U6.39
- new net ESP_UART_TX: U15.35, U6.38
- new net FPGA_LED_0: R80.2
- new net FPGA_LED_1: R79.2
- new net FPGA_LED_2: R59.2
- new net FPGA_LOGIC_NRST: R29.2, U1.E13
- new net LED_PWM_CONT_OUT: CN2.5, R33.1
- new net N$100: Q3.1, R12.1
- new net N$113: D6.A, R59.1
- new net N$114: D7.A, R79.1
- new net N$115: D5.A, R80.1
- new net N$14: C42.2, C47.2, D10.K, D8.K, U7.3, U7.5
- new net N$15: D13.2A, R72.2, U24.2
- new net N$16: CN5.A4, CN5.A9, CN5.B4, CN5.B9, FB1.1
- new net N$18: D13.2B, R13.2
- new net N$21: C85.2, D12.2B, R31.1, R32.2
- new net N$22: D14.2B, R16.2
- new net N$26: D14.2A, R14.2, U4.2
- new net N$27: D15.2B, R33.2
- new net N$99: Q2.1, R11.1
- new net PWR_USB_VBUS: C61.2, D10.A, FB1.2, U2.5
- new net SIG_PWR_BUS_UNREG: D12.2A, U15.16
- net AR_I2C_SCL: now also U16.5; no longer U1.E1
- net AR_I2C_SDA: now also U16.4; no longer U1.F1
- net FLS_SPI_CLK: now also U15.13; no longer R144.1, U4.6
- net FLS_SPI_MISO: now also U15.12; no longer R12.1, U4.2
- net FLS_SPI_MOSI: now also U15.11; no longer R11.1, U4.5
- net FLS_SPI_NCS: now also U15.14; no longer R142.1, U4.1
- net FPGA_CONF_CDONE: now also U15.6
- net FPGA_CONF_NCRST: now also U15.10; no longer C66.2
- net FT_CONT_RX: no longer U6.39
- net FT_CONT_TX: no longer U6.38
- net GND: now also C162.1, C163.1, C164.1, C83.1, C84.1, C85.1, C86.1, D12.1, D13.1, D14.1, D15.1, D5.K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; no longer CN4.1, R73.1, U25.3, U4.4
- net LED_PWM_CONT: now also D15.2A, U15.27; no longer CN2.5, U1.G11
- net MTR_CONT_N: now also U15.31; no longer U1.F13
- net MTR_CONT_P: now also U15.33; no longer U1.E13
- net MTR_SENSE_A: now also U15.30; no longer U1.F12
- net MTR_SENSE_B: now also U15.28, U4.4; no longer U1.G12, U25.4
- net MTR_SENSE_IN_A: now also R13.1; no longer R72.2, U24.2
- net MTR_SENSE_IN_B: now also R16.1; no longer R73.2, U25.2
- net PWR_BUS_UNREG: now also D8.A, R32.1; no longer C42.2, C47.2, U7.3, U7.5
- net PWR_SYS_1V8: now also C66.2, C83.2, C84.2, U16.1
- net PWR_SYS_3V3: now also C163.2, C164.2, C86.2, D12.3, D13.3, D14.3, D15.3, R129.2, R87.2, R89.2, R90.2, U15.2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; no longer C61.2, CN4.8, R11.2, R12.2, R13.2, R137.2, R138.2, R14.2, R142.2, R144.2, R16.2, U25.5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
Routing:
- net PWR_USB_VBUS: track 0.00 -> 122.1 mm, vias 0 -> 2
- net ESP_UART_NDTR: track 0.00 -> 94.2 mm, vias 0 -> 1
- net ESP_UART_RX: track 0.00 -> 92.9 mm, vias 0 -> 2
- net ESP_UART_NRTS: track 0.00 -> 92.0 mm, vias 0 -> 1
- net ESP_UART_TX: track 0.00 -> 91.3 mm, vias 0 -> 2
- net FPGA_LOGIC_NRST: track 0.00 -> 64.2 mm, vias 0 -> 2
- net MTR_SENSE_A: track 66.1 -> 10.9 mm
- net MTR_SENSE_B: track 61.1 -> 7.52 mm
- net FPGA_CONF_NCRST: track 17.6 -> 70.8 mm, vias 3 -> 4
- net MTR_CONT_P: track 77.2 -> 28.1 mm
- net PWR_BUS_UNREG: track 24.0 -> 73.1 mm, vias 1 -> 0
- net MTR_CONT_N: track 78.7 -> 32.1 mm
- net FPGA_CONF_CDONE: track 11.0 -> 56.0 mm, vias 0 -> 2
- net FLS_SPI_NCS: track 13.6 -> 57.1 mm, vias 0 -> 2
- net LED_PWM_CONT: track 51.6 -> 8.36 mm
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- removed copper zone on layer 1, net GND
- removed copper zone on layer 16, net GND
- removed copper zone on layer 1, net N$5
- removed copper zone on layer 1, net PWR_SYS_VIN
Other:
- board text removed: "Soke Eng. knokke 3.0.0 2024.04.0"

Commit message: LEDs routed. Text added. Pushed to Fusion
Parts:
- moved R80 82.7 mm to (-15.4, -7.25), flipped to the bottom
- moved D5 60.9 mm to (-12.9, -7.25), flipped to the bottom
- moved R79 53.4 mm to (18.1, 7.62), flipped to the bottom, turned to 180 degrees
- moved R59 51.8 mm to (18.1, 8.50), flipped to the bottom, turned to 180 degrees
- moved D7 49.2 mm to (13.5, 7.62), flipped to the bottom, turned to 180 degrees
- moved D6 47.3 mm to (13.5, 9.12), flipped to the bottom, turned to 180 degrees
- moved D11 23.2 mm to (49.0, 5.50), turned to 180 degrees
- moved D9 20.4 mm to (49.0, 2.62)
- moved R66 19.1 mm to (51.5, 5.50), turned to 180 degrees
- moved R58 17.2 mm to (51.5, 2.62), turned to 180 degrees
Connections:
- removed net FPGA_LED_1: R79.2
- removed net FPGA_LED_2: R59.2
- new net ESP_LED_0: R79.2, U15.36
- new net ESP_LED_1: R59.2, U15.37
- net FPGA_LED_0: now also U1.F13
Routing:
- net ESP_LED_0: track 0.00 -> 15.4 mm, vias 0 -> 1
- net ESP_LED_1: track 0.00 -> 14.7 mm, vias 0 -> 1
- net PWR_BUS_UNREG: track 73.1 -> 87.3 mm
- net GND: track 181.8 -> 193.6 mm, vias 187 -> 193
- net PWR_SYS_1V8: track 97.2 -> 107.1 mm
- net FPGA_LED_0: track 0.00 -> 4.88 mm, vias 0 -> 1
- net PWR_SYS_VIN: track 23.6 -> 27.6 mm
- net N$113: track 0.00 -> 3.63 mm
- net N$114: track 0.00 -> 3.38 mm
- net N$37: track 0.00 -> 1.25 mm
- net N$24: track 0.00 -> 1.25 mm
- net N$115: track 0.00 -> 1.25 mm
Other:
- board text added: "Soke Eng. - knokke 3.0.0 2024.04.01"
- board text removed: "Soke Eng. knokke 3.0.0 2024.04.01"
