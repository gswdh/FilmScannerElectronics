File: main.sch (EAGLE design)
At the start: 165 parts, among them CN1 DC-012A-D010, CN2 JST GH 6P V-TH, CN3 5.8ZSPT, CN4 FFC 8P 0.5mm, CN5 MC-118LS-H100, CN6 JST GH 6P V-TH, CN8 FFC 8P 0.5mm, Q1 GSFP0449, Q6 IRLML6244, U1 T20F169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

Commit message: Bidirectional motor controller added
Parts:
- removed D13: B360A-13-F, DIODES:B360A-13-F
- removed Q6: IRLML6244, TRANSISTORs:IRLML6244TRPBF
- added C81: 0.1uF 50V, c_0603:06035C104JAT2A
- added R27: 100R, r_0402:RC0402FR-10100RL
- added R28: 10k, r_0402:RC0402FR-0710KL
- added U14: AS4950, ICs:AS4950
- C33, C35, C36, C37: device c_0603:CL10A106KQ8NNWC -> c_0402:GRM155R60J106ME15D
- D3: value 12V BI TVS -> 18V BI TVS; device DIODES:SMBJ12CA-13-F -> DIODES:SMAJ18CA
- L1, L3: device INDUCTORS:CIGT252010EH1R0MNE -> INDUCTORS:BWVF002520121R0M00
Connections:
- removed net MTR_CONT_PWM: Q6.G, R68.2
- removed net N$57: C68.1, CN6.2, D13.A, Q6.D
- new net MTR_CONT_N: R68.2, U1.GPIOR_119_CTRL12, U14.IN2
- new net MTR_CONT_P: R28.2, U1.GPIOR_78_EXTFB0_CDI31, U14.IN1
- new net MTR_OUT_N: C81.1, CN6.1, U14.OUT-
- new net MTR_OUT_P: C81.2, CN6.2, U14.OUT+
- net GND: now also C68.1, R28.1, U14.GND, U14.ISEN; no longer Q6.S
- net LED_PWM_CONT: now also U1.GPIOR_88_CDI28; no longer U1.GPIOR_77_PLLIN1
- net MTR_SENSE_A: now also U1.GPIOR_77_PLLIN1; no longer U1.GPIOR_78_EXTFB0_CDI31
- net MTR_SENSE_B: now also U1.GPIOR_120_CLK15; no longer U1.GPIOR_119_CTRL12
- net PWR_BUS_UNREG: now also U14.VM; no longer CN6.1, D13.K
- net RAM_CLK_N: now also R27.1
- net RAM_CLK_P: now also R27.2
Other:
- moved on the sheet: C63, C64, C65, C67, C68, D1, R68, U13

Commit message: ESP32 added with architecture implemented. First attempt.
Parts:
- removed CN4: FFC 8P 0.5mm, CONNECTORs:HC-FPC-05-09-8RLTAG
- removed R137, R138, R142, R144, R73: 10k, r_0402:RC0402FR-0710KL
- removed U25: SCHMITT, ICs:SN74LVC1G17DBVR
- added C162, C163, C86: 0.1uF 10V, c_0402:C0402C104K8RAC7411
- added C164: 10uF 10V, CAPACITORS:GRM188R61A106KE69D
- added C83, C85: 0.1uF 16V, c_0402:0402YD104JAT2A
- added C84: 10uF 6.3V, c_0402:GRM155R60J106ME15D
- added D10, D8: B360A-13-F, DIODES:B360A-13-F
- added D12, D13, D14, D15: BAT54S-7-F, DIODES:BAT54S-7-F
- added D5, D6, D7: RED LED, OPTO:150060RS75000
- added FB1: 150R 100MHz, INDUCTORS:ILB1206ER151V
- added Q2, Q3: MMBT3904, TRANSISTORs:MMBT3904-7-F
- added R129, R87, R89, R90: 10k, r_0402:ERJ-2RKF1002X
- added R29, R33: 22R, r_0402:RC0402FR-0722RL
- added R31: 10k, r_0402:RC0402FR-0710KL
- added R32: 100k, r_0402:RC0402FR-07100KL
- added R59, R79, R80: 2.2k, r_0402:RC0402FR-072K2L
- added U15: ESP32, ICs:ESP32-WROOM-32D
- added U16: PI4ULS3V204ZBEX, ICs:PI4ULS3V204
- C61: value 0.1uF 16V -> 0.1uF 50V; device c_0402:0402YD104JAT2A -> c_0603:06035C104JAT2A
- C66: value 0.1uF 16V -> 0.1uF 10V; device c_0402:0402YD104JAT2A -> c_0402:C0402C104K8RAC7411
- R13, R16: value 10k -> 22R; device r_0402:RC0402FR-0710KL -> r_0402:RC0402FR-0722RL
- R2, R4: value 1.5k -> 2.2k; device r_0402:RC0402FR-071K5L -> r_0402:RC0402FR-072K2L
- R3: value 10R -> 22R; device r_0402:RC0402FR-0710RL -> r_0402:RC0402FR-0722RL
- U4: value W25Q128JV -> SCHMITT; device ICs:W25Q128JVSIQ -> ICs:SN74LVC1G17DBVR
Connections:
- removed net FLS_NHOLD: R138.1, U4.!HOLD!/IO3
- removed net N$38: R137.1, U4.!WP!/IO2
- removed net PROC_JTAG_TCK: CN4.4, R13.1, U1.GPIOB_TXP00
- removed net PROC_JTAG_TDI: CN4.5, U1.GPIOB_TXN05
- removed net PROC_JTAG_TDO: CN4.2, R14.1, U1.GPIOB_TXN00
- removed net PROC_JTAG_TMS: CN4.3, U1.GPIOL_21_CTRL1_CDI5
- removed net PROC_NRST: CN4.7, R16.1, U1.GPIOL_25_CLK1
- removed net USB_VBUS: CN5.VBUS, U2.VBUS
- new net ESP_EN: C162.2, Q2.C, R87.1, U15.EN
- new net ESP_I2C_SCL: U15.IO33, U16.B4
- new net ESP_I2C_SDA: U15.IO32, U16.B3
- new net ESP_IO0: Q3.C, R29.1, R89.1, U15.IO0
- new net ESP_IO5: R129.1, U15.IO5
- new net ESP_UART_NDTR: Q3.E, R11.2, U6.BDBUS4
- new net ESP_UART_NRTS: Q2.E, R12.2, U6.BDBUS2
- new net ESP_UART_RX: R90.1, U15.RXD0, U6.BDBUS1
- new net ESP_UART_TX: U15.TXD0, U6.BDBUS0
- new net FPGA_LED_0: R80.2
- new net FPGA_LED_1: R79.2
- new net FPGA_LED_2: R59.2
- new net FPGA_LOGIC_NRST: R29.2, U1.GPIOR_78_EXTFB0_CDI31
- new net LED_PWM_CONT_OUT: CN2.5, R33.1
- new net N$100: Q3.B, R12.1
- new net N$113: D6.A, R59.1
- new net N$114: D7.A, R79.1
- new net N$115: D5.A, R80.1
- new net N$14: C42.2, C47.2, D10.K, D8.K, U7.EN, U7.VIN
- new net N$15: D13.AK1, R72.2, U24.A
- new net N$16: CN5.VBUS, FB1.1
- new net N$18: D13.AK2, R13.2
- new net N$21: C85.2, D12.AK2, R31.1, R32.2
- new net N$22: D14.AK2, R16.2
- new net N$26: D14.AK1, R14.2, U4.A
- new net N$27: D15.AK2, R33.2
- new net N$99: Q2.B, R11.1
- new net PWR_USB_VBUS: C61.2, D10.A, FB1.2, U2.VBUS
- new net SIG_PWR_BUS_UNREG: D12.AK1, U15.IO13
- net AR_I2C_SCL: now also U16.A4; no longer U1.GPIOL_20_CTRL0_CDI4
- net AR_I2C_SDA: now also U16.A3; no longer U1.GPIOL_12_CDI2
- net FLS_SPI_CLK: now also U15.IO14; no longer R144.1, U4.SCK
- net FLS_SPI_MISO: now also U15.IO27; no longer R12.1, U4.SO/IO1
- net FLS_SPI_MOSI: now also U15.IO26; no longer R11.1, U4.SI/IO0
- net FLS_SPI_NCS: now also U15.IO12; no longer R142.1, U4.!CE
- net FPGA_CONF_CDONE: now also U15.IO34
- net FPGA_CONF_NCRST: now also U15.IO25; no longer C66.2
- net FT_CONT_RX: no longer U6.BDBUS1
- net FT_CONT_TX: no longer U6.BDBUS0
- net GND: now also C162.1, C163.1, C164.1, C83.1, C84.1, C85.1, C86.1, D12.A, D13.A, D14.A, D15.A, D5.K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; no longer CN4.1, R73.1, U25.GND
- net LED_PWM_CONT: now also D15.AK1, U15.IO16; no longer CN2.5, U1.GPIOR_88_CDI28
- net MTR_CONT_N: now also U15.IO19; no longer U1.GPIOR_119_CTRL12
- net MTR_CONT_P: now also U15.IO21; no longer U1.GPIOR_78_EXTFB0_CDI31
- net MTR_SENSE_A: now also U15.IO18; no longer U1.GPIOR_77_PLLIN1
- net MTR_SENSE_B: now also U15.IO17, U4.Q; no longer U1.GPIOR_120_CLK15, U25.Q
- net MTR_SENSE_IN_A: now also R13.1; no longer R72.2, U24.A
- net MTR_SENSE_IN_B: now also R16.1; no longer R73.2, U25.A
- net PWR_BUS_UNREG: now also D8.A, R32.1; no longer C42.2, C47.2, U7.EN, U7.VIN
- net PWR_SYS_1V8: now also C66.2, C83.2, C84.2, U16.VCCA
- net PWR_SYS_3V3: now also C163.2, C164.2, C86.2, D12.K, D13.K, D14.K, D15.K, R129.2, R87.2, R89.2, R90.2, U15.3V3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; no longer C61.2, CN4.8, R11.2, R12.2, R13.2, R137.2, R138.2, R14.2, R142.2, R144.2, R16.2, U25.VCC
Other:
- moved on the sheet: C68, C69, C70, C71, C72, C73, C74, C75, C76, C77, C78, C79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
