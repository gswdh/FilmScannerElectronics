File: main.sch (EAGLE design)
At the start: 137 parts, among them CN1 USB C 2.0, CN2 JST GH 10 Pin, CN3 15PIN 0.5MM, CN4 8 PIN FFC, CN5 NEB-21-R, CN6 S4B-XH-SM4-TB, CN7 8 PIN FFC, Q1 GSFP0449, SW1 DPDT, U1 TPS54302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

Commit message: Control and sensor merged into main
Parts:
- added C49, C51, C60, C61, C62, C63, C71, C72, C73, C74, C75: 100nF 16V, CAPACITORS:CL10B104KO8WPNC
- added C50: 10uF 25V, c_1206:C1206C106K3RACAUTO
- added C76, C78: 0.1uF 16V, c_0402:0402YC104KAT2A
- added C77, C79: 10uF 10V, c_0603:0603ZD106KAT2A
- added C80, C84: 100uF 50V, CAPACITORS:107CKR050M
- added C81, C83, C85, C87, C89, C91: 0.1uF 50V, c_0603:06035C104JAT2A
- added C82: 100pF 50V, c_0603:06035A101J4T4A
- added C86, C88, C90, C92: 1uF 10V, c_0603:C0603C105K8PAC7411
- added C93, C94, C95, C96, C97: 10uF 10V, c_1206:1206ZC106KAT2A
- added FB1: 150R 100MHz, INDUCTORS:ILB1206ER151V
- added FB2: 600R, INDUCTORS:742792651
- added Q2: 2SCR586D, TRANSISTORs:2SCR586DGTL
- added Q3: MMBT3904, TRANSISTORs:MMBT3904-7-F
- added R22, R25, R27, R29, R31, R33: 430R, r_0402:RC0402FR-07430RL
- added R23: 10k, r_0603:CRCW060310K0FKTA
- added R24, R26, R28, R30, R32, R34: 110k, r_0402:RC0402FR-07110KL
- added R35: 20k, r_0603:CRCW060320K0FKEA
- added R36, R38, R40, R42: 240R, r_0402:RC0402FR-07240RL
- added R37, R39, R41, R43: 715R, r_0402:RC0402FR-07715RL
- added U10, U11, U12, U13, U14, U15, U16, U17, U19, U9: SN74LVC2G17, ICs:SN74LVC2G17DBVR
- added U20: R2A20169SA#W5, ICs:R2A20169SA#W5
- added U21, U22, U33, U34: LM317MDT, ICs:LM317MDT-TR
- added U8: TCD2720BFG, ICs:TCD2720BFG
Connections:
- new net CCD_1A1: U8.1A1, U9B.Q
- new net CCD_1A2: U8.1A2
- new net CCD_1A3: U11B.Q, U8.1A3
- new net CCD_1A4: U12B.Q, U8.1A4
- new net CCD_1A5: U17C.Q, U8.1A5
- new net CCD_2A1: U8.2A1, U9C.Q
- new net CCD_2A2: U10C.Q, U8.2A2
- new net CCD_2A3: U11C.Q, U8.2A3
- new net CCD_2A4: U19B.Q, U8.2A4
- new net CCD_2A5: U19C.Q, U8.2A5
- new net CCD_2B: U10B.Q, U8.2B
- new net CCD_CP: U13B.Q, U8.CP
- new net CCD_RS: U13C.Q, U8.RS
- new net CCD_SH_M1: U15B.Q, U8.SH_M1
- new net CCD_SH_M2: U15C.Q, U8.SH_M2
- new net CCD_SH_S1: U14C.Q, U8.SH_S1
- new net CCD_SH_S2: U16B.Q, U8.SH_S2
- new net CCD_SH_S3: U14B.Q, U8.SH_S3
- new net CCD_SH_S4: U16C.Q, U8.SH_S4
- new net CCD_SIG_1A: U11B.A, U12B.A, U17C.A, U9B.A
- new net CCD_SIG_2A: U10B.A, U10C.A, U11C.A, U19B.A, U19C.A, U9C.A
- new net CCD_SIG_CP: U13B.A
- new net CCD_SIG_RS: U13C.A
- new net CCD_SIG_SH_M1: U15B.A
- new net CCD_SIG_SH_M2: U15C.A
- new net CCD_SIG_SH_S1: U14C.A
- new net CCD_SIG_SH_S2: U16B.A
- new net CCD_SIG_SH_S3: U14B.A
- new net CCD_SIG_SH_S4: U16C.A
- new net CCD_SIG_SW: U17B.A
- new net CCD_SIG_TG: U12C.A
- new net CCD_SW: U17B.Q, U8.SW
- new net CCD_TG: U12C.Q, U8.TG
- new net DAC_SPI_MOSI: U20.DI
- new net DAC_SPI_NCS: U20.LD
- new net DAC_SPI_SCLK: U20.CLK
- new net N$21: C49.2, C50.2, FB1.2, U8.OD
- new net N$22: R22.1, U20.AO1
- new net N$23: R24.1, U20.AO2
- new net N$26: R25.1, U20.AO3
- new net N$27: R26.1, U20.AO4
- new net N$28: R27.1, U20.AO5
- new net N$29: R28.1, U20.AO6
- new net N$30: R29.1, U20.AO7
- new net N$31: R30.1, U20.AO8
- new net N$32: R31.1, U20.AO9
- new net N$33: R32.1, U20.AO10
- new net N$34: R33.1, U20.AO11
- new net N$35: R34.1, U20.AO12
- new net N$36: C81.2, C82.2, FB2.2, Q2.C, Q3.C, R23.2
- new net N$39: C80.A, C83.2, Q3.B, R23.1, R35.2
- new net N$40: Q2.B, Q3.E
- new net N$52: C95.2, R36.1, R37.2, U21.ADJ
- new net N$53: R38.1, R39.2, U22.ADJ
- new net N$54: C96.2, R40.1, R41.2, U33.ADJ
- new net N$55: C94.2, R42.1, R43.2, U34.ADJ
- new net PWR_ANA_10V: C90.2, FB1.1, R40.2, U33.VOUT
- new net PWR_ANA_3V3: C76.2, C77.2, C78.2, C79.2, C92.2, R42.2, U20.VCC, U20.VREFH, U34.VOUT
- new net PWR_ANA_5V: C86.2, R36.2, U21.VOUT
- new net PWR_ANA_UNREG: C84.A, C85.2, C89.2, C91.2, Q2.E, U21.VIN, U33.VIN, U34.VIN
- new net PWR_BUS_24V_UNREG: FB2.1
- new net PWR_CLK_5V: C51.2, C60.2, C61.2, C62.2, C63.2, C71.2, C72.2, C73.2, C74.2, C75.2, C88.2, C93.2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
- new net SEN_OFFSET_OS1: R22.2, R24.2
- new net SEN_OFFSET_OS2: R25.2, R26.2
- new net SEN_OFFSET_OS3: R27.2, R28.2
- new net SEN_OFFSET_OS4: R29.2, R30.2
- new net SEN_OFFSET_OS5: R31.2, R32.2
- new net SEN_OFFSET_OS6: R33.2, R34.2
- new net SEN_SIG_OS1: U8.OS1
- new net SEN_SIG_OS2: U8.OS2
- new net SEN_SIG_OS3: U8.OS3
- new net SEN_SIG_OS4: U8.OS4
- new net SEN_SIG_OS5: U8.OS5
- new net SEN_SIG_OS6: U8.OS6
- net GND: now also C49.1, C50.1, C51.1, C60.1, C61.1, C62.1, C63.1, C71.1, C72.1, C73.1, C74.1, C75.1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
- net PWR_SYS_12V: now also C87.2, U22.VIN

Commit message: FTDI and CCD routed
Parts:
- removed SW1: DPDT, ELECTROMECH:PBH2UEESNPNAGX
- added C106, C107, C109, C111, C112, C113, C114, C115, C117, C119, C120, C121, C122, C123, C125, C127, C128, C129, C138, C139, C141, C143, C144, C145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: 0.1uF 16V, c_0402:0402YC104KAT2A
- added C108, C116, C124, C140, C148, C164: 220pF 25V, c_0402:04023A221FAT2A
- added C110, C118, C126, C142, C150, C166: NO FIT, c_0402:C0402C100J3GACAUTO
- added R47, R50, R53, R60, R63, R69: 100R, r_0402:RC0402FR-10100RL
- added R48, R51, R54, R61, R64, R70: 330R, r_0402:RC0402FR-07330RL
- added R49, R52, R55, R62, R65, R71: 680R, r_0402:RC0402FR-07680RL
- added U27, U30, U35, U41, U44, U50: ADS7056, ICs:ADS7056IRUGR
- added U28, U31, U36, U42, U45, U51: AD5258BRMZ1-R7, ICs:AD5258BRMZ1-R7
- added U29, U32, U37, U43, U46, U52: COS8092SR, ICs:COS8092SRD
- CN1: value USB C 2.0 -> DC-012A-D010; device CONNECTORs:MC-107D -> CONNECTORs:DC-012A-D010
- CN3: value 15PIN 0.5MM -> 5.8ZSPT; device CONNECTORs:SFV15R-1STE1HLF -> ELECTROMECH:5.8ZSPT
- CN5: value NEB-21-R -> MC-118LS-H100; device CONNECTORs:NEB-21-R -> CONNECTORs:MC-118LS-H100
- R41: value 715R -> 1.69k; device r_0402:RC0402FR-07715RL -> r_0402:RC0402FR-071K69L
- R43: value 715R -> 390R; device r_0402:RC0402FR-07715RL -> r_0402:RC0402FR-07390RL
Connections:
- removed net GPIOB_N0: U18.GPIOB_RXN00
- removed net GPIOB_N2: U18.GPIOB_RXN02
- removed net GPIOB_N3: U18.GPIOB_RXN03
- removed net GPIOB_N7: U18.GPIOB_RXN07
- removed net GPIOB_P0: U18.GPIOB_RXP00
- removed net GPIOB_P2: U18.GPIOB_RXP02
- removed net GPIOB_P3: U18.GPIOB_RXP03
- removed net GPIOB_P7: U18.GPIOB_RXP07
- removed net GPIOB_TN0: U18.GPIOB_TXN00
- removed net GPIOB_TN11: U18.GPIOB_TXN11
- removed net GPIOB_TN2: U18.GPIOB_TXN02
- removed net GPIOB_TN4: U18.GPIOB_TXN04
- removed net GPIOB_TN6: U18.GPIOB_TXN06
- removed net GPIOB_TN9: U18.GPIOB_TXN09
- removed net GPIOB_TP0: U18.GPIOB_TXP00
- removed net GPIOB_TP11: U18.GPIOB_TXP11
- removed net GPIOB_TP2: U18.GPIOB_TXP02
- removed net GPIOB_TP4: U18.GPIOB_TXP04
- removed net GPIOB_TP6: U18.GPIOB_TXP06
- removed net GPIOB_TP9: U18.GPIOB_TXP09
- removed net GPIOL_12: U18.GPIOL_12_CDI2
- removed net GPIOL_13: U18.GPIOL_13_CDI3
- removed net GPIOL_20: U18.GPIOL_20_CTRL0_CDI4
- removed net GPIOL_21: U18.GPIOL_21_CTRL1_CDI5
- removed net GPIOL_22: U18.GPIOL_22_CTRL2
- removed net GPIOL_24: U18.GPIOL_24_CLK0
- removed net GPIOL_25: U18.GPIOL_25_CLK1
- removed net GPIOL_31: U18.GPIOL_31_CLK7_CDI6
- removed net GPIOL_32: U18.GPIOL_32_CTRL4_CDI7
- removed net GPIOL_40: U18.GPIOL_40_CDI8
- removed net GPIOL_41: U18.GPIOL_41_CDI9
- removed net GPIOL_46: U18.GPIOL_46
- removed net GPIOL_53: U18.GPIOL_53_CDI10
- removed net GPIOL_54: U18.GPIOL_54_CDI11
- removed net PWR_LED_24V: C4.2, C5.2, C6.A, CN2.10, CN2.8, CN2.9, Q1.D, U1.VIN
- new net ADC_SPI_MISO_1: U27.MISO
- new net ADC_SPI_MISO_2: U35.MISO
- new net ADC_SPI_MISO_3: U41.MISO
- new net ADC_SPI_MISO_4: U30.MISO
- new net ADC_SPI_MISO_5: U44.MISO
- new net ADC_SPI_MISO_6: U50.MISO
- new net ADC_SPI_NCS: U27.!CS, U30.!CS, U35.!CS, U41.!CS, U44.!CS, U50.!CS
- new net ADC_SPI_SCLK: U27.SCLK, U30.SCLK, U35.SCLK, U41.SCLK, U44.SCLK, U50.SCLK
- new net N$100: R70.1, U52B.-, U52B.OUT
- new net N$61: C108.2, R47.2, U27.AINP
- new net N$62: C110.2, R47.1, R49.2, U29A.OUT
- new net N$63: C110.1, R48.2, U28.B, U29A.-
- new net N$64: R49.1, U28.W
- new net N$65: R48.1, U29B.-, U29B.OUT
- new net N$66: C116.2, R50.2, U30.AINP
- new net N$67: C118.2, R50.1, R52.2, U32A.OUT
- new net N$68: C118.1, R51.2, U31.B, U32A.-
- new net N$69: R52.1, U31.W
- new net N$70: R51.1, U32B.-, U32B.OUT
- new net N$71: C124.2, R53.2, U35.AINP
- new net N$72: C126.2, R53.1, R55.2, U37A.OUT
- new net N$73: C126.1, R54.2, U36.B, U37A.-
- new net N$74: R55.1, U36.W
- new net N$75: R54.1, U37B.-, U37B.OUT
- new net N$81: C140.2, R60.2, U41.AINP
- new net N$82: C142.2, R60.1, R62.2, U43A.OUT
- new net N$83: C142.1, R61.2, U42.B, U43A.-
- new net N$84: R62.1, U42.W
- new net N$85: R61.1, U43B.-, U43B.OUT
- new net N$86: C148.2, R63.2, U44.AINP
- new net N$87: C150.2, R63.1, R65.2, U46A.OUT
- new net N$88: C150.1, R64.2, U45.B, U46A.-
- new net N$89: R65.1, U45.W
- new net N$90: R64.1, U46B.-, U46B.OUT
- new net N$96: C164.2, R69.2, U50.AINP
- new net N$97: C166.2, R69.1, R71.2, U52A.OUT
- new net N$98: C166.1, R70.2, U51.B, U52A.-
- new net N$99: R71.1, U51.W
- new net POT_I2C0_SCL: U28.SCL, U36.SCL, U42.SCL
- new net POT_I2C0_SDA: U28.SDA, U36.SDA, U42.SDA
- new net POT_I2C1_SCL: U31.SCL, U45.SCL, U51.SCL
- new net POT_I2C1_SDA: U31.SDA, U45.SDA, U51.SDA
- net CCD_SH_M1: now also U15C.Q; no longer U15B.Q
- net CCD_SH_M2: now also U15B.Q; no longer U15C.Q
- net CCD_SIG_1A: now also U18.GPIOB_RXP03
- net CCD_SIG_2A: now also U18.GPIOB_RXN07
- net CCD_SIG_CP: now also U18.GPIOB_CLKN0
- net CCD_SIG_RS: now also U18.GPIOB_RXP12_EXTFB0
- net CCD_SIG_SH_M1: now also U15C.A, U18.GPIOB_RXP07; no longer U15B.A
- net CCD_SIG_SH_M2: now also U15B.A, U18.GPIOB_TXP06; no longer U15C.A
- net CCD_SIG_SH_S1: now also U18.GPIOB_RXP10
- net CCD_SIG_SH_S2: now also U18.GPIOB_RXP02
- net CCD_SIG_SH_S3: now also U18.GPIOB_RXN10
- net CCD_SIG_SH_S4: now also U18.GPIOB_RXN02
- net CCD_SIG_SW: now also U18.GPIOB_RXN03
- net CCD_SIG_TG: now also U18.GPIOB_RXN12_EXTFB0
- net FPGA_CONF_CSI: now also CN4.3; no longer CN4.6
- net FPGA_CONF_NCRST: now also CN4.2; no longer CN4.7
- net FPGA_JTAG_TCK: now also CN4.5; no longer CN4.3
- net FPGA_JTAG_TDI: now also CN4.4; no longer CN4.2
- net FPGA_JTAG_TDO: now also CN4.7; no longer CN4.5
- net FPGA_JTAG_TMS: now also CN4.6; no longer CN4.4
- net FPGA_STATUS: no longer U18.GPIOR_136_CDI16
- net FT_CLKOUT: now also U18.GPIOB_CLKP0; no longer U18.GPIOR_77_PLLIN1
- net FT_CONT_NCTS: now also U18.GPIOL_32_CTRL4_CDI7; no longer U18.GPIOR_88_CDI28
- net FT_CONT_NDCD: now also U18.GPIOL_31_CLK7_CDI6; no longer U18.GPIOR_104_CDI25
- net FT_CONT_NDSR: now also U18.GPIOL_22_CTRL2; no longer U18.GPIOR_95_CDI26
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
Commit message: Board routed, needs motor driver and thorough review
Parts:
- removed C64, C65, C66, C69: 100nF 16V, CAPACITORS:CL10B104KO8WPNC
- removed C67: 100uF 25V, CAPACITORS:UVY1E101MDD
- removed C68: 2.2uF 10V, c_0603:0603ZC225KAT2A
- removed C70: 0.022uF 50V, c_0603:C0603C223K5REC7867
- removed C94, C95: 10uF 10V, c_1206:1206ZC106KAT2A
- removed CN6: S4B-XH-SM4-TB, CONNECTORs:S4B-XH-SM4-TB
- removed R16, R17: 0.33R, RESISTORS:CRL0603-FW-R330ELF
- removed U23: TMC2208-LA-T, ICs:TMC2208-LA-T
- added R44, R45, R46, R56: 2.2k, r_0402:RC0402FR-072K2L
- C90: value 1uF 10V -> 1uF 16V; device c_0603:C0603C105K8PAC7411 -> c_1206:1206YC105JAT2A
Connections:
- removed net ADC_SPI_NCS: U27.!CS, U30.!CS, U35.!CS, U41.!CS, U44.!CS, U50.!CS
- removed net ADC_SPI_SCLK: U27.SCLK, U30.SCLK, U35.SCLK, U41.SCLK, U44.SCLK, U50.SCLK
- removed net GPIOL_64: U18.GPIOL_64
- removed net GPIOL_65: U18.GPIOL_65
- removed net GPIOL_66: U18.GPIOL_66_CDI12
- removed net GPIOL_67: U18.GPIOL_67_CDI13
- removed net GPIOR_128: U18.GPIOR_128_CTRL11
- removed net GPIOR_129: U18.GPIOR_129_CTRL10
- removed net GPIOR_132: U18.GPIOR_132_CDI19
- removed net GPIOR_133: U18.GPIOR_133_CDI18
- removed net N$18: C68.2, U23.5VOUT
- removed net N$24: C69.1, U23.VCP
- removed net N$37: C70.2, U23.CPI
- removed net N$38: C70.1, U23.CPO
- removed net N$47: R16.1, U23.BRA
- removed net N$48: R17.1, U23.BRB
- removed net STP_CLK: U23.CLK
- removed net STP_DIA: U23.DIAG
- removed net STP_DIR: U23.DIR
- removed net STP_IDX: U23.INDEX
- removed net STP_MS1: U23.MS1
- removed net STP_MS2: U23.MS2
- removed net STP_MTR_A1: CN6.2, U23.OA1
- removed net STP_MTR_A2: CN6.1, U23.OA2
- removed net STP_MTR_B1: CN6.3, U23.OB1
- removed net STP_MTR_B2: CN6.4, U23.OB2
- removed net STP_NEN: U23.ENN
- removed net STP_STP: U23.STEP
- removed net STP_UART_IO: U23.PDN_UART
- new net ADC_SPI_NCS_1: U18.GPIOR_83, U27.!CS
- new net ADC_SPI_NCS_2: U18.GPIOR_85, U35.!CS
- new net ADC_SPI_NCS_3: U18.GPIOR_94_CDI27, U41.!CS
- new net ADC_SPI_NCS_4: U18.GPIOR_125_CLK10, U30.!CS
- new net ADC_SPI_NCS_5: U18.GPIOR_136_CDI16, U44.!CS
- new net ADC_SPI_NCS_6: U18.GPIOR_132_CDI19, U50.!CS
- new net ADC_SPI_SCLK_1: U18.GPIOR_86, U27.SCLK
- new net ADC_SPI_SCLK_2: U18.GPIOR_88_CDI28, U35.SCLK
- new net ADC_SPI_SCLK_3: U18.GPIOR_104_CDI25, U41.SCLK
- new net ADC_SPI_SCLK_4: U18.GPIOR_129_CTRL10, U30.SCLK
- new net ADC_SPI_SCLK_5: U18.GPIOR_139, U44.SCLK
- new net ADC_SPI_SCLK_6: U18.GPIOR_135_CDI17, U50.SCLK
- new net N$101: U18.GPIOR_113_CDI22
- new net N$102: U18.GPIOR_116_CTRL15
- new net N$103: U18.GPIOR_117_CTRL14
- new net N$104: U18.GPIOR_122_CLK13_CDI21
- new net N$105: U18.GPIOR_123_CLK12_CDI20
- new net N$59: U18.GPIOR_105_CDI24
- new net N$60: U18.GPIOR_112_CDI23
- new net N$76: U18.GPIOL_73_EXTFB1_CDI15
- new net N$77: U18.GPIOL_74_PLLIN0
- new net N$78: U18.GPIOL_75_PLLIN1
- new net N$79: U18.GPIOR_76_PLLIN0
- new net N$80: U18.GPIOR_77_PLLIN1
- new net N$91: U18.GPIOR_78_EXTFB0_CDI31
- new net N$92: U18.GPIOR_79_EXTFB1_CDI30
- new net N$93: U18.GPIOR_80
- new net N$94: U18.GPIOR_81_MREFCLK
- new net N$95: U18.GPIOR_82
- net ADC_SPI_MISO_1: now also U18.GPIOR_84
- net ADC_SPI_MISO_2: now also U18.GPIOR_87_CDI29
- net ADC_SPI_MISO_3: now also U18.GPIOR_95_CDI26
- net ADC_SPI_MISO_4: now also U18.GPIOR_128_CTRL11
- net ADC_SPI_MISO_5: now also U18.GPIOR_138
- net ADC_SPI_MISO_6: now also U18.GPIOR_133_CDI18
- net DAC_SPI_MOSI: now also U18.GPIOL_72_EXTFB0_CDI14
- net DAC_SPI_NCS: now also U18.GPIOL_70_CBSEL0
- net DAC_SPI_SCLK: now also U18.GPIOL_71_NSTATUS
- net GND: no longer C64.1, C65.1, C66.1, C67.K, C68.1, C94.1, C95.1, R16.2, R17.2, U23.GND
- net N$52: no longer C95.2
- net N$55: no longer C94.2
- net POT_I2C0_SCL: now also R44.1, U18.GPIOL_65
- net POT_I2C0_SDA: now also R45.1, U18.GPIOL_66_CDI12
- net POT_I2C1_SCL: now also R46.1, U18.GPIOR_154
- net POT_I2C1_SDA: now also R56.1, U18.GPIOR_155
- net PROC_JTAG_TCK: now also U18.GPIOL_67_CDI13
- net PROC_JTAG_TDI: now also U18.GPIOL_64
- net PROC_JTAG_TDO: now also U18.GPIOL_69_CBSEL1
- net PROC_JTAG_TMS: now also U18.GPIOL_68
- net PWR_SYS_12V: no longer C65.2, C66.2, C67.A, C69.2, U23.VS
- net PWR_SYS_3V3: now also R44.2, R45.2, R46.2, R56.2; no longer C64.2, U23.VCCIO
