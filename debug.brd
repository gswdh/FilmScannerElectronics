# Repository gswdh/FilmScannerElectronics (continued)

## EAGLE design control.brd (continued)

Parts:
C8, C9, C10, C11, C12, C13, C14, C15, C16, C17, C26, C27, C28, C29, C30, C31, C32, C33, C35: 100nF 16V; 0603
C21, C22, C25, C34, C38, C52, C53, C54, C55, C56, C57, C59: 0.1uF 16V; 0603
C23, C24: 10pF 100V; 0603
C36, C37: 10uF 6.3V; 0603
C39: 33pF 10V; 0603
C58: 4.7uF 6.3V; 0603
CN1: USB C 2.0; MC-107D
CN3: 15PIN 0.5MM; SFV15R-1STE1HLF
CN4, CN7: 8 PIN FFC; SFV8R-1STBE1HLF
D5, D6, D7, D8, D10: RED LED; 0603_POLAR
FB3: 150R 100MHz; 1206
L3: 1uH; 1008
MECH1, MECH2, MECH3, MECH4: 6mm x 3mm; MOUNTHOLE_6X3
OSC1: 33MHz; KC2016Z
R3, R7, R8, R9, R20, R21, R126, R130, R137, R138, R139, R140, R141, R142, R143, R144, R145, R146, R147: 10k; 0603
R6: 12k; 0603
R10, R11, R12, R13, R14, R59: 2.2k; 0603
R148, R149: 180k; 0603
U2: USBLC6-2SC6; SOT23-6
U3: 93LC56B-I/SN; SO8
U4: W25Q128JV; SO8-208MIL
U5: TPS62065; WSON8
U6: FT2232H; QFN64
U18: T8Q144C4; QFP144
XTAL2: 12MHz; 3.2X3.5SMD

Connections:
FLS_NHOLD: R138.1, U4.7 (!HOLD!/IO3)
FLS_SPI_CLK: R144.1, U4.6 (SCK), U18.30 (GPIOL_01_CCK)
FLS_SPI_MISO: U4.2 (SO/IO1), U18.28 (GPIOL_09_CDI1)
FLS_SPI_MOSI: U4.5 (SI/IO0), U18.29 (GPIOL_08_CDI0)
FLS_SPI_NCS: R142.1, U4.1 (!CE), U18.31 (GPIOL_00_SS_N)
FPGA_CLK_33M: OSC1.3 (OUT), U18.75 (GPIOR_157_PLLIN)
FPGA_CONF_CBUS_0: R141.1, U18.78 (GPIOR_151_CBUS0)
FPGA_CONF_CBUS_1: R140.1, U18.79 (GPIOR_150_CBUS1)
FPGA_CONF_CBUS_2: R139.1, U18.80 (GPIOR_149_CBUS2)
FPGA_CONF_CDONE: R147.1, U18.34 (CDONE)
FPGA_CONF_CSI: CN4.6, R145.1, U18.32 (GPIOL_04_CSI)
FPGA_CONF_NCRST: CN4.7, R146.1, U18.35 (CRESET_N)
FPGA_CONF_NTEST: R143.1, U18.74 (GPIOR_158_TEST_N)
FPGA_JTAG_TCK: CN4.3, R3.1, U18.26 (TCK)
FPGA_JTAG_TDI: CN4.2, U18.27 (TDI)
FPGA_JTAG_TDO: CN4.5, R130.1, U18.24 (TDO)
FPGA_JTAG_TMS: CN4.4, U18.25 (TMS)
FPGA_STATUS: D6.K, U18.83 (GPIOR_136_CDI16)
FT_CLKOUT: U6.32 (ACBUS5), U18.123 (GPIOR_77_PLLIN1)
FT_CONT_NCTS: U6.41 (BDBUS3), U18.109 (GPIOR_88_CDI28)
FT_CONT_NDCD: U6.45 (BDBUS6), U18.103 (GPIOR_104_CDI25)
FT_CONT_NDSR: U6.44 (BDBUS5), U18.105 (GPIOR_95_CDI26)
FT_CONT_NDTR: U6.43 (BDBUS4), U18.106 (GPIOR_94_CDI27)
FT_CONT_NRI: U6.46 (BDBUS7), U18.102 (GPIOR_105_CDI24)
FT_CONT_NRTS: U6.40 (BDBUS2), U18.110 (GPIOR_87_CDI29)
FT_CONT_NRXLED: D8.K, U6.54 (BCBUS3)
FT_CONT_NTXLED: D7.K, U6.55 (BCBUS4)
FT_CONT_PWRSAV: U6.59 (BCBUS7), U18.99 (GPIOR_116_CTRL15)
FT_CONT_RX: U6.39 (BDBUS1), U18.111 (GPIOR_85)
FT_CONT_TX: U6.38 (BDBUS0), U18.112 (GPIOR_86)
FT_CONT_TXDEN: U6.48 (BCBUS0), U18.101 (GPIOR_112_CDI23)
FT_D0: U6.16 (ADBUS0), U18.139 (GPIOL_68)
FT_D1: U6.17 (ADBUS1), U18.138 (GPIOL_69_CBSEL1)
FT_D2: U6.18 (ADBUS2), U18.137 (GPIOL_70_CBSEL0)
FT_D3: U6.19 (ADBUS3), U18.136 (GPIOL_71_NSTATUS)
FT_D4: U6.21 (ADBUS4), U18.135 (GPIOL_72_EXTFB0_CDI14)
FT_D5: U6.22 (ADBUS5), U18.134 (GPIOL_73_EXTFB1_CDI15)
FT_D6: U6.23 (ADBUS6), U18.132 (GPIOL_74_PLLIN0)
FT_D7: U6.24 (ADBUS7), U18.131 (GPIOL_75_PLLIN1)
FT_NOE: U6.33 (ACBUS6), U18.115 (GPIOR_82)
FT_NPWREN: U6.60 (!PWREN), U18.100 (GPIOR_113_CDI22)
FT_NRD: U6.28 (ACBUS2), U18.119 (GPIOR_78_EXTFB0_CDI31)
FT_NRST: U6.14 (!RESET), U18.124 (GPIOR_76_PLLIN0)
FT_NRXF: U6.26 (ACBUS0), U18.117 (GPIOR_80)
FT_NSIWU: U6.30 (ACBUS4), U18.114 (GPIOR_83)
FT_NSUSPEND: U6.36 (!SUSPEND), U18.113 (GPIOR_84)
FT_NTXE: U6.27 (ACBUS1), U18.116 (GPIOR_81_MREFCLK)
FT_NWR: U6.29 (ACBUS3), U18.118 (GPIOR_79_EXTFB1_CDI30)
GND: C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C21.1, C22.1, C23.1, C24.1, C25.1, C26.1, C27.1, C28.2, C29.1, C30.1, C31.1, C32.1, C33.1, C34.1, C35.1, C36.1, C37.1, C38.1, C52.1, C53.1, C54.1, C55.1, C56.1, C57.1, C58.1, C59.1, CN1.A12B1 (GND), CN1.B12A1 (GND), CN1.P$1 (GND), CN1.P$2 (GND), CN1.P$3 (GND), CN1.P$4 (GND), CN1.P$5 (GND), CN1.P$6 (GND), CN1.P$7 (GND), CN1.P$8 (GND), CN1.P$9 (GND), CN1.P$10 (GND), CN1.P$11 (GND), CN1.P$12 (GND), CN1.P$13 (GND), CN1.P$14 (GND), CN1.P$15 (GND), CN1.P$16 (GND), CN1.P$17 (GND), CN1.P$18 (GND), CN1.P$19 (GND), CN1.P$20 (GND), CN1.P$21 (GND), CN1.P$22 (GND), CN1.P$23 (GND), CN1.P$24 (GND), CN4.8, CN7.8, OSC1.2 (GND), R6.1, R126.1, R149.1, U2.2 (GND), U3.5 (GND), U4.4 (GND), U5.1 (GND), U5.3 (GND), U5.6 (MODE), U5.PAD (GND), U6.1 (GND), U6.5 (GND), U6.10 (GND), U6.11 (GND), U6.13 (TEST)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; also elsewhere on the board
GPIOB_N0: U18.56 (GPIOB_RXN00)
GPIOB_N2: U18.59 (GPIOB_RXN02)
GPIOB_N3: U18.60 (GPIOB_RXN03)
GPIOB_N7: U18.65 (GPIOB_RXN07)
GPIOB_P0: U18.55 (GPIOB_RXP00)
GPIOB_P2: U18.58 (GPIOB_RXP02)
GPIOB_P3: U18.61 (GPIOB_RXP03)
GPIOB_P7: U18.66 (GPIOB_RXP07)
GPIOB_TN0: U18.39 (GPIOB_TXN00)
GPIOB_TN2: U18.41 (GPIOB_TXN02)
GPIOB_TN4: U18.43 (GPIOB_TXN04)
GPIOB_TN6: U18.46 (GPIOB_TXN06)
GPIOB_TN9: U18.48 (GPIOB_TXN09)
GPIOB_TN11: U18.54 (GPIOB_TXN11)
GPIOB_TP0: U18.38 (GPIOB_TXP00)
GPIOB_TP2: U18.40 (GPIOB_TXP02)
GPIOB_TP4: U18.42 (GPIOB_TXP04)
GPIOB_TP6: U18.45 (GPIOB_TXP06)
GPIOB_TP9: U18.47 (GPIOB_TXP09)
GPIOB_TP11: U18.53 (GPIOB_TXP11)
GPIOL_12: U18.20 (GPIOL_12_CDI2)
GPIOL_13: U18.19 (GPIOL_13_CDI3)
GPIOL_20: U18.18 (GPIOL_20_CTRL0_CDI4)
GPIOL_21: U18.17 (GPIOL_21_CTRL1_CDI5)
GPIOL_22: U18.16 (GPIOL_22_CTRL2)
GPIOL_24: U18.15 (GPIOL_24_CLK0)
GPIOL_25: U18.14 (GPIOL_25_CLK1)
GPIOL_31: U18.11 (GPIOL_31_CLK7_CDI6)
GPIOL_32: U18.10 (GPIOL_32_CTRL4_CDI7)
GPIOL_40: U18.8 (GPIOL_40_CDI8)
GPIOL_41: U18.7 (GPIOL_41_CDI9)
GPIOL_46: U18.6 (GPIOL_46)
GPIOL_53: U18.3 (GPIOL_53_CDI10)
GPIOL_54: U18.4 (GPIOL_54_CDI11)
GPIOL_64: U18.144 (GPIOL_64)
GPIOL_65: U18.141 (GPIOL_65)
GPIOL_66: U18.142 (GPIOL_66_CDI12)
GPIOL_67: U18.140 (GPIOL_67_CDI13)
GPIOR_128: U18.90 (GPIOR_128_CTRL11)
GPIOR_129: U18.89 (GPIOR_129_CTRL10)
GPIOR_132: U18.87 (GPIOR_132_CDI19)
GPIOR_133: U18.86 (GPIOR_133_CDI18)
unnamed: L3.1, U5.2 (SW)
unnamed: C39.1, R148.1, R149.2, U5.4 (FB)
unnamed: R137.1, U4.3 (!WP!/IO2)
unnamed: CN1.A6 (D+), CN1.B6 (D+), U2.3 (D-_IN)
unnamed: CN1.A7 (D-), CN1.B7 (D-), U2.1 (D+_IN)
unnamed: D5.A, R11.1
unnamed: D6.A, R12.1
unnamed: D7.A, R13.1
unnamed: D8.A, R14.1
unnamed: CN1.A9B4 (VBUS), CN1.B9A4 (VBUS), FB3.1
unnamed: R6.2, U6.6 (REF)
unnamed: R7.1, U3.1 (CS), U6.63 (EECS)
unnamed: R8.1, U3.2 (CLK), U6.62 (EECLK)
unnamed: R10.2, U3.3 (DI), U6.61 (EEDATA)
unnamed: R9.1, R10.1, U3.4 (DO)
unnamed: C23.2, U6.3 (XCSO), XTAL2.3
unnamed: C24.2, U6.2 (XCSI), XTAL2.1
unnamed: C55.2, C56.2, C57.2, C58.2, U6.12 (VCORE), U6.37 (VCORE), U6.49 (VREGOUT), U6.64 (VCORE)
unnamed: D10.A, R59.1
unnamed: R126.2, U18.36 (REF_RES)
PROC_JTAG_TCK: CN7.3, R20.1, U18.97 (GPIOR_122_CLK13_CDI21)
PROC_JTAG_TDI: CN7.2, U18.98 (GPIOR_117_CTRL14)
PROC_JTAG_TDO: CN7.5, R21.1, U18.92 (GPIOR_125_CLK10)
PROC_JTAG_TMS: CN7.4, U18.93 (GPIOR_123_CLK12_CDI20)
PROC_SCANNING: D10.K, U18.81 (GPIOR_139)
PROC_STATUS: D5.K, U18.82 (GPIOR_138)
PWR_FPGA_1V2: C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C26.2, C37.2, C39.2, L3.2, R148.2, U18.2 (VCCA_TL), U18.13 (VCC), U18.22 (VCC), U18.49 (VCC), U18.57 (VCC), U18.73 (VCCA_BR), U18.85 (VCC), U18.96 (VCC), U18.107 (VCCA_TR), U18.125 (VCC), U18.128 (VCC), U18.130 (VCC)
PWR_SYS_3V3: C22.2, C25.2, C27.2, C28.1, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C38.2, C52.2, C53.2, C54.2, C59.2, CN4.1, CN7.1, OSC1.1 (!ST), OSC1.4 (VCC), R3.2, R7.2, R8.2, R9.2, R11.2, R12.2, R13.2, R14.2, R20.2, R21.2, R59.2, R130.2, R137.2, R138.2, R139.2, R140.2, R141.2, R142.2, R143.2, R144.2, R145.2, R146.2, R147.2, U3.8 (V+), U4.8 (VCC), U5.5 (EN), U5.7 (VIN), U5.8 (VIN), U6.4 (VPHY), U6.9 (VPLL), U6.20 (VCCIO), U6.31 (VCCIO), U6.42 (VCCIO), U6.50 (VREGIN), U6.56 (VCCIO), U18.12 (VCCIO1C_1D), U18.21 (VCCIO1B), U18.23 (VCCIO1A), U18.51 (VCCIO4B), U18.52 (VCCIO4B), U18.62 (VCCIO4A), U18.63 (VCCIO4A), U18.88 (VCCIO3E), U18.91 (VCCIO3D), U18.95 (VCCIO3B_3C), U18.122 (VCCIO3A), U18.143 (VCCIO1E); also elsewhere on the board
PWR_USB_VBUS: C21.2, FB3.2, U2.5 (VBUS)
STP_CLK: U18.71 (GPIOB_CLKP0); also elsewhere on the board
STP_DIA: U18.84 (GPIOR_135_CDI17); also elsewhere on the board
STP_DIR: U18.68 (GPIOB_RXN10); also elsewhere on the board
STP_IDX: U18.72 (GPIOB_CLKN0); also elsewhere on the board
STP_MS1: U18.76 (GPIOR_155); also elsewhere on the board
STP_MS2: U18.77 (GPIOR_154); also elsewhere on the board
STP_NEN: U18.67 (GPIOB_RXP10); also elsewhere on the board
STP_STP: U18.69 (GPIOB_RXN12_EXTFB0); also elsewhere on the board
STP_UART_IO: U18.70 (GPIOB_RXP12_EXTFB0); also elsewhere on the board
USB_D_N: U2.6 (D+_OUT), U6.7 (D-)
USB_D_P: U2.4 (D-OUT), U6.8 (D+)

Notes on the sheet:
UNCONTROLLED WHEN PRINTED

Parts:
C1, C43, C64, C65, C66, C69: 100nF 16V; 0603
C2, C6: 100uF 50V; 8MM_RADIAL_3.5MM_PITCH
C3, C7: 100pF 50V; 0603
C4: 10uF 50V; 1210
C5, C47: 0.1uF 50V; 0603
C18, C19, C20, C40, C41, C42, C44, C45, C46: 10uF 50V; 0805
C48: NO FIT; 0603
C67: 100uF 25V; 5MM_RADIAL_2MM_PITCH
C68: 2.2uF 10V; 0603
C70: 0.022uF 50V; 0603
CN2: JST GH 10 Pin; 1.25-10PWT
CN5: NEB-21-R
CN6: S4B-XH-SM4-TB
D1, D2: B360A-13-F; DO214AC
D3: 12V BI TVS; DO214AC
D4: BZX585-C10; SOD_523
L1: 15uH 6.5A; SRP1035A
L2: 2.2uH 3.5A; SRN5040
Q1: GSFP0449; SO8_POWERPAK
R1, R5, R19: 10k; 0603
R2: 51k; 0603
R4: 100k; 0603
R15: 5.23k; 0603
R16, R17: 0.33R; 0603
R18: 34k; 0603
SW1: DPDT; PBH2UEESNPNAGX
U1: TPS54302; SOT23-6
U7: TPS563201; SOT23-6
U23: TMC2208-LA-T; QFN28

Connections:
GND: C2.N (K), C4.1, C5.1, C6.N (K), C18.1, C19.1, C20.1, C40.1, C41.1, C42.1, C44.1, C45.1, C46.1, C47.1, C64.1, C65.1, C66.1, C67.2 (K), C68.1, CN2.4, CN2.5, CN2.6, CN2.7, CN5.3 (GND), D2.A, D3.A, R15.1, R16.2, R17.2, R19.1, SW1.2 (1), U1.1 (GND), U7.1 (GND), U23.3 (GND), U23.18 (GND), U23.29 (GND); also elsewhere on the board
LED_PWM_CONT: CN2.3
unnamed: C7.2, D4.A, Q1.4 (G), R1.2, R5.2
unnamed: C1.1, U1.6 (BOOT)
unnamed: CN5.1 (V+), D1.A, D3.K
unnamed: C1.2, L1.1, U1.2 (SW)
unnamed: C3.2, R2.1, R4.2
unnamed: C3.1, R4.1, R15.2, U1.4 (FB)
unnamed: C43.1, U7.6 (BOOT)
unnamed: R5.1, SW1.3
unnamed: C68.2, U23.8 (5VOUT)
unnamed: C2.P (A), C7.1, D1.K, D2.K, D4.K, Q1.1 (S), Q1.2 (S), Q1.3 (S), R1.1
unnamed: C43.2, L2.1, U7.2 (SW)
unnamed: C69.1, U23.6 (VCP)
unnamed: C48.1, R18.1, R19.2, U7.4 (FB)
unnamed: C70.2, U23.5 (CPI)
unnamed: C70.1, U23.4 (CPO)
unnamed: R16.1, U23.23 (BRA)
unnamed: R17.1, U23.27 (BRB)
PWR_LED_24V: C4.2, C5.2, C6.P (A), CN2.8, CN2.9, CN2.10, Q1.5 (D), Q1.6 (D), Q1.7 (D), Q1.8 (D), Q1.PAD (D), U1.3 (VIN)
PWR_SYS_3V3: C44.2, C45.2, C46.2, C48.2, C64.2, L2.2, R18.2, U23.15 (VCCIO); also elsewhere on the board
PWR_SYS_12V: C18.2, C19.2, C20.2, C40.2, C41.2, C42.2, C47.2, C65.2, C66.2, C67.1 (A), C69.2, L1.2, R2.2, U7.3 (VIN), U7.5 (EN), U23.22 (VS), U23.28 (VS)
STP_CLK: U23.13 (CLK); also elsewhere on the board
STP_DIA: U23.11 (DIAG); also elsewhere on the board
STP_DIR: U23.19 (DIR); also elsewhere on the board
STP_IDX: U23.12 (INDEX); also elsewhere on the board
STP_MS1: U23.9 (MS1); also elsewhere on the board
STP_MS2: U23.10 (MS2); also elsewhere on the board
STP_MTR_A1: CN6.2, U23.24 (OA1)
STP_MTR_A2: CN6.1, U23.21 (OA2)
STP_MTR_B1: CN6.3, U23.26 (OB1)
STP_MTR_B2: CN6.4, U23.1 (OB2)
STP_NEN: U23.2 (ENN); also elsewhere on the board
STP_STP: U23.16 (STEP); also elsewhere on the board
STP_UART_IO: U23.14 (PDN_UART); also elsewhere on the board
TEMP_SEN_A: CN2.2
TEMP_SEN_B: CN2.1

Notes on the sheet:
UNCONTROLLED WHEN PRINTED
