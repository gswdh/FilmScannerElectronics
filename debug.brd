# Repository gswdh/FilmScannerElectronics (continued)

## EAGLE design main.brd (continued)

Parts:
C1, C27, C41, C50, C51: 1uF 10V; 0402
C3, C10, C14, C17, C29, C31, C33, C35: 10uF 6.3V; 0402
C4, C5, C8, C9, C11, C12, C13, C15, C16, C18, C19, C20, C21, C26, C30, C32, C60: 0.1uF 16V; 0402
C40: 150pF 25V; 0402
C66, C86: 0.1uF 10V; 0402
L1: 1uH; 1008
R2, R4, R38, R39: 2.2k; 0402
R15: 36k; 0402
R17: 20k; 0402
R20: 16k; 0402
R22: 62k; 0402
R23: 30k; 0402
R24: 12k; 0402
U8: AR0822; PBGA75
U9: TPS62065; WSON8
U10, U12: AP7335; DFN2020-6
U16: PI4ULS3V204ZBEX; TQFN14

Connections:
AR_CLK: U8.G6 (EXTCLK); also elsewhere on the board
AR_GPIO0: U8.B10 (GPIO_0); also elsewhere on the board
AR_GPIO1: U8.A10 (GPIO_1); also elsewhere on the board
AR_GPIO2: U8.B11 (GPIO_2); also elsewhere on the board
AR_GPIO3: U8.A11 (GPIO_3); also elsewhere on the board
AR_I2C_SCL: R4.1, U8.C11 (SCL), U16.5 (A4)
AR_I2C_SDA: R2.1, U8.C12 (SDA), U16.4 (A3)
AR_MIPI_CLK_N: U8.A5 (CLKN); also elsewhere on the board
AR_MIPI_CLK_P: U8.B5 (CLKP); also elsewhere on the board
AR_MIPI_D0_N: U8.A7 (DATA0N); also elsewhere on the board
AR_MIPI_D0_P: U8.B7 (DATA0P); also elsewhere on the board
AR_MIPI_D1_N: U8.A6 (DATA1N); also elsewhere on the board
AR_MIPI_D1_P: U8.B6 (DATA1P); also elsewhere on the board
AR_MIPI_D2_N: U8.A4 (DATA2N); also elsewhere on the board
AR_MIPI_D2_P: U8.B4 (DATA2P); also elsewhere on the board
AR_MIPI_D3_N: U8.A3 (DATA3N); also elsewhere on the board
AR_MIPI_D3_P: U8.B3 (DATA3P); also elsewhere on the board
AR_NRESET: U8.H6 (!RESET); also elsewhere on the board
AR_XSHUTDOWN: U8.G5 (XSHUTDOWN); also elsewhere on the board
ESP_I2C_SCL: R39.1, U16.10 (B4); also elsewhere on the board
ESP_I2C_SDA: R38.1, U16.11 (B3); also elsewhere on the board
GND: C1.1, C3.1, C4.1, C5.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C26.1, C27.1, C29.1, C30.1, C31.1, C32.1, C33.1, C35.1, C41.1, C50.1, C51.1, C60.1, C66.1, C86.1, R20.1, R22.1, R24.1, U8.B1 (AGND), U8.D2 (AGND), U8.D4 (GND), U8.D5 (GND), U8.D6 (GND), U8.D7 (GND), U8.D8 (GND), U8.D9 (GND), U8.E2 (AGND), U8.E4 (GND), U8.E5 (GND), U8.E6 (GND), U8.E7 (GND), U8.E8 (GND), U8.E9 (GND), U8.E11 (GND), U8.G3 (AGND), U8.G4 (GND), U8.G7 (SADDR0), U8.G8 (GND), U8.G9 (AGND), U8.G10 (GND), U8.G11 (AGND), U8.H1 (GND), U8.H3 (AGND), U8.H4 (AGND), U8.H5 (GND), U8.H7 (SADDR1), U8.H8 (SADDR2), U8.H9 (AGND), U8.H10 (AGND), U9.1 (GND), U9.3 (GND), U9.6 (MODE), U9.PAD (GND), U10.2 (GND), U10.7 (GND), U12.2 (GND), U12.7 (GND), U16.7 (GND); also elsewhere on the board
unnamed: L1.1, U9.2 (SW)
unnamed: C1.2, U8.F2 (VAA2V8_FILT)
unnamed: C40.1, R15.1, R22.2, U9.4 (FB)
unnamed: R17.1, R20.2, U10.6 (FB)
unnamed: R23.1, R24.2, U12.6 (FB)
PWR_SEN_1V05D: C17.2, C18.2, C19.2, C20.2, C21.2, C26.2, C29.2, C30.2, C31.2, C32.2, C35.2, C40.2, L1.2, R15.2, U8.A8 (DVDDPHY), U8.A9 (DVDD), U8.A12 (DVDD), U8.B8 (DVDDCORE), U8.D12 (DVDD), U8.E12 (DVDD), U8.F1 (DVDD), U8.G2 (DVDD), U8.G12 (DVDD)
PWR_SEN_2V8A: C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C51.2, C60.2, R23.2, U8.A2 (VAA2V8_ANA), U8.C1 (VAA2V8_PIX), U8.D1 (VAA2V8_ANA), U8.F12 (VAA2V8_ANA), U8.G1 (VAA2V8_PIX), U8.H2 (VAA2V8_ANA), U8.H11 (VAA2V8_PIX), U8.H12 (VAA2V8_ANA), U12.4 (VOUT)
PWR_SYS_1V8: C3.2, C4.2, C5.2, C8.2, C9.2, C41.2, C66.2, R2.2, R4.2, R17.2, U8.B9 (VDDIO), U8.B12 (VDDIO), U8.D11 (VDDIO), U8.E1 (VDDIO), U10.4 (VOUT), U16.1 (VCCA), U16.8 (EN); also elsewhere on the board
PWR_SYS_3V3: C27.2, C33.2, C50.2, C86.2, R38.2, R39.2, U9.5 (EN), U9.7 (VIN), U9.8 (VIN), U10.1 (ON), U10.3 (VIN), U12.1 (ON), U12.3 (VIN), U16.14 (VCCB); also elsewhere on the board

Notes on the sheet:
UNCONTROLLED WHEN PRINTED

Parts:
C22, C28, C34, C38, C52, C53, C54, C55, C56, C57, C59: 0.1uF 16V; 0402
C23, C24: 10pF 10V; 0402
C58: 10uF 6.3V; 0402
C61: 0.1uF 50V; 0603
CN5: MC-118LS-H100
FB1: 150R 100MHz; 1206
Q2, Q3: MMBT3904; SOT23-3
R6: 12k; 0402
R7, R8, R9, R11, R12: 10k; 0402
R10: 2.2k; 0402
U2: USBLC6-2SC6; SOT23-6
U3: 93LC56B-I/SN; SO8
U6: FT2232H; QFN64
XTAL2: 12MHz; 3.2X3.5SMD

Connections:
ESP_EN: Q2.2 (C); also elsewhere on the board
ESP_IO0: Q3.2 (C); also elsewhere on the board
ESP_UART_NDTR: Q3.3 (E), R11.2, U6.43 (BDBUS4)
ESP_UART_NRTS: Q2.3 (E), R12.2, U6.40 (BDBUS2)
ESP_UART_RX: U6.39 (BDBUS1); also elsewhere on the board
ESP_UART_TX: U6.38 (BDBUS0); also elsewhere on the board
FT_CLKOUT: U6.32 (ACBUS5); also elsewhere on the board
FT_D0: U6.16 (ADBUS0); also elsewhere on the board
FT_D1: U6.17 (ADBUS1); also elsewhere on the board
FT_D2: U6.18 (ADBUS2); also elsewhere on the board
FT_D3: U6.19 (ADBUS3); also elsewhere on the board
FT_D4: U6.21 (ADBUS4); also elsewhere on the board
FT_D5: U6.22 (ADBUS5); also elsewhere on the board
FT_D6: U6.23 (ADBUS6); also elsewhere on the board
FT_D7: U6.24 (ADBUS7); also elsewhere on the board
FT_NOE: U6.33 (ACBUS6); also elsewhere on the board
FT_NRD: U6.28 (ACBUS2); also elsewhere on the board
FT_NRST: U6.14 (!RESET); also elsewhere on the board
FT_NRXF: U6.26 (ACBUS0); also elsewhere on the board
FT_NSIWU: U6.30 (ACBUS4); also elsewhere on the board
FT_NTXE: U6.27 (ACBUS1); also elsewhere on the board
FT_NWR: U6.29 (ACBUS3); also elsewhere on the board
GND: C22.1, C23.1, C24.1, C28.1, C34.1, C38.1, C52.1, C53.1, C54.1, C55.1, C56.1, C57.1, C58.1, C59.1, C61.1, CN5.A1 (GND), CN5.A12 (GND), CN5.B1 (GND), CN5.B12 (GND), CN5.SHELL1 (GND), CN5.SHELL2 (GND), CN5.SHELL3 (GND), CN5.SHELL4 (GND), CN5.SHELL5 (GND), CN5.SHELL6 (GND), CN5.SHELL7 (GND), CN5.SHELL8 (GND), CN5.SHELL9 (GND), CN5.SHELL10 (GND), CN5.SHELL11 (GND), CN5.SHELL12 (GND), R6.1, U2.2 (GND), U3.5 (GND), U6.1 (GND), U6.5 (GND), U6.10 (GND), U6.11 (GND), U6.13 (TEST), U6.15 (GND), U6.25 (GND), U6.35 (GND), U6.41 (BDBUS3), U6.44 (BDBUS5), U6.45 (BDBUS6), U6.47 (GND), U6.51 (GND), U6.PAD (GND), XTAL2.2 (GND), XTAL2.4 (GND); also elsewhere on the board
LED_FT_CONT_NRXLED: U6.54 (BCBUS3)
LED_FT_CONT_NTXLED: U6.55 (BCBUS4)
unnamed: CN5.A6 (D+), CN5.B6 (D+), U2.3 (D-_IN)
unnamed: CN5.A7 (D-), CN5.B7 (D-), U2.1 (D+_IN)
unnamed: CN5.A4 (VBUS), CN5.A9 (VBUS), CN5.B4 (VBUS), CN5.B9 (VBUS), FB1.1
unnamed: R6.2, U6.6 (REF)
unnamed: R7.1, U3.1 (CS), U6.63 (EECS)
unnamed: R8.1, U3.2 (CLK), U6.62 (EECLK)
unnamed: R10.2, U3.3 (DI), U6.61 (EEDATA)
unnamed: R9.1, R10.1, U3.4 (DO)
unnamed: C23.2, U6.3 (XCSO), XTAL2.3
unnamed: C24.2, U6.2 (XCSI), XTAL2.1
unnamed: C55.2, C56.2, C57.2, C58.2, U6.12 (VCORE), U6.37 (VCORE), U6.49 (VREGOUT), U6.64 (VCORE)
unnamed: Q2.1 (B), R11.1
unnamed: Q3.1 (B), R12.1
PWR_SYS_3V3: C22.2, C28.2, C34.2, C38.2, C52.2, C53.2, C54.2, C59.2, R7.2, R8.2, R9.2, U3.8 (V+), U6.4 (VPHY), U6.9 (VPLL), U6.20 (VCCIO), U6.31 (VCCIO), U6.42 (VCCIO), U6.46 (BDBUS7), U6.50 (VREGIN), U6.56 (VCCIO), U6.59 (BCBUS7); also elsewhere on the board
PWR_USB_VBUS: C61.2, FB1.2, U2.5 (VBUS); also elsewhere on the board
USB_D_N: U2.6 (D+_OUT), U6.7 (D-)
USB_D_P: U2.4 (D-OUT), U6.8 (D+)

Notes on the sheet:
UNCONTROLLED WHEN PRINTED
