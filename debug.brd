# Repository gswdh/FilmScannerElectronics (continued)

## EAGLE design main.brd (continued)

Parts:
C2, C6: 470uF 25V; 10MM_RADIAL_5MM_PITCH
C7: 100pF 25V; 0402
C42, C44, C45, C46: 10uF 50V; 0805
C43, C68, C85, C87: 0.1uF 16V; 0402
C47, C69, C70: 0.1uF 50V; 0603
C48: NO FIT; 0402
C81: 2.2uF 6.3V; 0402
C88: 0.022uF 16V; 0402
CN1: DC-012A-D010
CN2, CN6: JST GH 6P V-TH; PH-6P-V-TH
CN3: 5.8ZSPT
D1, D2, D8, D10: B360A-13-F; DO214AC
D3: 18V BI TVS; DO214AC
D4: BZX585-C10; SOD_523
D9, D11: RED LED; 0603_POLAR
D12, D15: BAT54S-7-F; SOT23-3-BAT54S
L2: 2.2uH 3.5A; SRN5040
MECH1, MECH2, MECH3, MECH4: 6mm x 3mm; MOUNTHOLE_6X3
Q1: FDD5614P; TO252
R1, R5, R13, R14, R16, R19, R31, R58, R66: 10k; 0402
R18: 34k; 0402
R28, R30: 0.33R; 0603
R32: 100k; 0402
R33: 22R; 0402
U4: TMC2208-LA-T; QFN28
U7: TPS563201; SOT23-6

Connections:
GND: C2.1 (K), C6.1 (K), C42.1, C44.1, C45.1, C46.1, C47.1, C68.1, C69.1, C70.1, C81.1, C85.1, C87.1, CN1.-1 (GND), CN1.-2 (GND), CN1.-3 (GND), CN1.-4 (GND), CN1.-5 (GND), CN1.-6 (GND), CN1.-7 (GND), CN1.-8 (GND), CN2.3, CN2.4, CN2.6, CN3.2 (1), CN6.2, CN6.5, D2.A, D3.A, D9.K, D11.K, D12.1 (A), D15.1 (A), R16.2, R19.1, R28.2, R30.2, R31.2, U4.3 (GND), U4.13 (CLK), U4.18 (GND), U4.29 (GND), U7.1 (GND); also elsewhere on the board
LED_PWM_CONT: D15.2A (AK1); also elsewhere on the board
LED_PWM_CONT_OUT: CN2.5, R33.1
MTR_A_N: CN6.6, U4.21 (OA2)
MTR_A_P: CN6.4, U4.24 (OA1)
MTR_B_N: CN6.1, U4.1 (OB2)
MTR_B_P: CN6.3, U4.26 (OB1)
MTR_DIR: U4.19 (DIR); also elsewhere on the board
MTR_MS1: U4.9 (MS1); also elsewhere on the board
MTR_MS2: U4.10 (MS2); also elsewhere on the board
MTR_NEN: R13.2, U4.2 (ENN); also elsewhere on the board
MTR_STP: U4.16 (STEP); also elsewhere on the board
MTR_UART_BIDIR: U4.14 (PDN_UART); also elsewhere on the board
unnamed: C7.2, D4.A, Q1.1 (G), R1.2, R5.2
unnamed: CN1.+1 (V+), CN1.+2 (V+), CN1.+3 (V+), CN1.+4 (V+), CN1.+5 (V+), CN1.+6 (V+), CN1.+7 (V+), CN1.+8 (V+), CN1.+9 (V+), CN1.+10 (V+), CN1.+11 (V+), D1.A, D3.K
unnamed: C43.1, U7.6 (BOOT)
unnamed: CN3.3, R5.1
unnamed: C42.2, C47.2, D8.K, D10.K, U7.3 (VIN), U7.5 (EN)
unnamed: C43.2, L2.1, U7.2 (SW)
unnamed: C85.2, D12.2B (AK2), R31.1, R32.2
unnamed: D9.A, R58.1
unnamed: C48.1, R18.1, R19.2, U7.4 (FB)
unnamed: D15.2B (AK2), R33.2
unnamed: R14.1, R16.1, U4.17 (VREF)
unnamed: C81.2, R14.2, U4.8 (5VOUT)
unnamed: C87.2, U4.6 (VCP)
unnamed: C88.2, U4.5 (CPI)
unnamed: D11.A, R66.1
unnamed: C88.1, U4.4 (CPO)
unnamed: R28.1, U4.23 (BRA)
unnamed: R30.1, U4.27 (BRB)
PWR_BUS_UNREG: C6.2 (A), C69.2, C70.2, CN2.1, CN2.2, D8.A, Q1.2 (D), R32.1, R58.2, U4.22 (VS), U4.28 (VS)
PWR_SYS_3V3: C44.2, C45.2, C46.2, C48.2, C68.2, D12.3 (K), D15.3 (K), L2.2, R13.1, R18.2, U4.15 (VCCIO); also elsewhere on the board
PWR_SYS_VIN: C2.2 (A), C7.1, D1.K, D2.K, D4.K, Q1.3 (S), R1.1, R66.2
PWR_USB_VBUS: D10.A; also elsewhere on the board
SIG_PWR_BUS_UNREG: D12.2A (AK1); also elsewhere on the board

Notes on the sheet:
UNCONTROLLED WHEN PRINTED

Board: 4 copper layers, 130.0 x 34.0 mm, 199 parts (79 on the bottom side), 145 nets.

Other parts of the board:
MECH5, MECH6, MECH7, MECH8: 6mm x 3mm; MOUNTHOLE_6X3

## EAGLE design led.brd

Parts:
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12: 5000K; LH502C
MECH1, MECH2, MECH3, MECH4: 6mm x 3mm; MOUNTHOLE_6X3
TP1, TP2: 2MM_TEST_POINT; 2MM_TEST_PAD

Connections:
ANODE: D1.A, D2.A, D3.A, D4.A, D5.A, D6.A, TP1.1
CATHODE: D7.K, D8.K, D9.K, D10.K, D11.K, D12.K, TP2.1
unnamed: D1.K, D7.A
unnamed: D2.K, D8.A
unnamed: D3.K, D9.A
unnamed: D4.K, D10.A
unnamed: D5.K, D11.A
unnamed: D6.K, D12.A

Board: 4 copper layers, 28.0 x 34.0 mm, 18 parts (0 on the bottom side), 8 nets.

## EAGLE design led_drv.brd

Parts:
C1, C2: 0.1uF 50V; 0603
C3: 1uF 25V; 0603
C4: 2.2uF 10V; 0603
MECH1, MECH2: 6mm x 3mm; MOUNTHOLE_6X3
Q1: FDD5612; TO252
R1, R4: 100R; 0603
R3: 0.33R; 0603
R5: 20k; 0603
R6: 10k; 0603
TP1, TP2, TP3, TP4, TP5, TP6: TEST_POINT_SQUARE; OSPREY_HSS_PAD
U1: NCS20071; SOT23-5
U2: TPS70950; SOT23-5

Connections:
GND: C2.1, C3.1, C4.1, R3.1, TP3.1, U1.2 (V-), U2.2 (GND)
GND_SIG: C1.1, R6.1, TP4.1
LED_PWM_CONT: R5.1, TP1.1
unnamed: Q1.3 (S), R1.2, R3.2
unnamed: Q1.2 (D), TP6.1
unnamed: C1.2, R5.2, R6.2, U1.3 (+)
unnamed: Q1.1 (G), R4.2
unnamed: R4.1, U1.1 (OUT)
unnamed: R1.1, U1.4 (-)
unnamed: C2.2, C4.2, U1.5 (V+), U2.5 (VOUT)
PWR_LED_18V: C3.2, TP2.1, TP5.1, U2.1 (VIN), U2.3 (EN)

Board: 4 copper layers, 30.0 x 20.0 mm, 20 parts (0 on the bottom side), 11 nets.

## EAGLE design control.brd

Notes on the sheet:
2023.06.28 - GSWDH LTD. MOON CONTROLLER REVISION 1.0.0 DESIGN BY GEORGE WALLER AT GSWDH LTD. GEORGEWALLER@GSWDH.CO.UK CONFIDENTIAL. FOR THE INTENDED READER ONLY.
UNCONTROLLED WHEN PRINTED
