# Repository gswdh/FilmScannerElectronics (continued)

## EAGLE design control.brd (continued)

Board: 4 copper layers, 50.0 x 95.0 mm, 137 parts (1 on the bottom side), 112 nets.

## EAGLE design sensor.brd

Notes on the sheet:
2023.06.28 - GSWDH LTD. MOON CONTROLLER REVISION 1.0.0 DESIGN BY GEORGE WALLER AT GSWDH LTD. GEORGEWALLER@GSWDH.CO.UK CONFIDENTIAL. FOR THE INTENDED READER ONLY.
UNCONTROLLED WHEN PRINTED

Parts:
C1, C58, C59, C60, C61, C62, C63: 100nF 16V; 0603
C2: 10uF 25V; 1206
C3, C4, C6, C18, C19, C21, C23, C24, C34, C52, C53, C54, C55, C56, C57: 0.1uF 16V; 0402
C5, C20, C25: 220pF 25V; 0402
C7, C22, C38: NO FIT; 0402
CN3: 15PIN 0.5MM; SFV15R-1STE1HLF
FB1: 150R 100MHz; 1206
MECH1, MECH2, MECH3, MECH4: 6mm x 3mm; MOUNTHOLE_6X3
R1, R5, R8: 100R; 0402
R2, R6, R9: 330R; 0402
R4, R7, R10: 680R; 0402
U1: TCD2565BFG
U3, U7, U9: ADS7056; X2QFN8
U6, U8, U10: LT1806; SOT23-6
U11, U12, U13, U14, U15, U20: SN74LVC2G17; SOT23-6
U19, U21, U22: AD5258BRMZ1-R7; MSOP10

Connections:
ADC_OS1_SPI_MISO: U9.2 (MISO)
ADC_OS2_SPI_MISO: U7.2 (MISO)
ADC_OS3_SPI_MISO: U3.2 (MISO)
ADC_SPI_NCS: U3.1 (!CS), U7.1 (!CS), U9.1 (!CS)
ADC_SPI_SCLK: U3.3 (SCLK), U7.3 (SCLK), U9.3 (SCLK)
CCD_1A: U1.8 (1A), U1.15 (1A), U1.17 (1A), U11.4 (Q), U11.6 (Q)
CCD_2A: U1.5 (2B), U1.6 (2A), U1.9 (2A), U1.14 (2A), U12.4 (Q), U12.6 (Q)
CCD_CP: U1.3 (CP), U13.6 (Q)
CCD_RS: U1.4 (RS), U13.4 (Q)
CCD_SH1: U1.13 (SH1), U20.4 (Q)
CCD_SH2A: U1.11 (SH2A), U15.4 (Q)
CCD_SH2B: U1.12 (SH2B), U20.6 (Q)
CCD_SH3: U1.10 (SH3), U15.6 (Q)
CCD_SW: U1.18 (SW), U14.4 (Q)
CCD_TG: U1.16 (TG), U14.6 (Q)
GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C18.1, C19.1, C20.1, C21.1, C23.1, C24.1, C25.1, C34.1, C52.1, C53.1, C54.1, C55.1, C56.1, C57.1, C58.1, C59.1, C60.1, C61.1, C62.1, C63.1, U1.2 (SS), U1.7 (SS), U3.5 (GND), U3.8 (AINM), U6.2 (V-), U7.5 (GND), U7.8 (AINM), U8.2 (V-), U9.5 (GND), U9.8 (AINM), U10.2 (V-), U19.3 (A1), U19.7 (GND), U21.2 (A0), U21.3 (A1), U21.7 (GND), U22.2 (A0), U22.7 (GND); also elsewhere on the board
unnamed: C1.2, C2.2, FB1.2, U1.19 (OD), U1.20 (OD)
unnamed: C5.2, R1.2, U3.7 (AINP)
unnamed: C7.2, R1.1, R4.2, U6.1 (OUT)
unnamed: C7.1, R2.2, U6.4 (-), U21.9 (B)
unnamed: U11.1 (A), U11.3 (A)
unnamed: R7.1, U19.1 (W)
unnamed: R4.1, U21.1 (W)
unnamed: U12.1 (A), U12.3 (A)
unnamed: R10.1, U22.1 (W)
unnamed: C38.1, R9.2, U10.4 (-), U22.9 (B)
unnamed: C20.2, R5.2, U7.7 (AINP)
unnamed: C22.2, R5.1, R7.2, U8.1 (OUT)
unnamed: C22.1, R6.2, U8.4 (-), U19.9 (B)
unnamed: C25.2, R8.2, U9.7 (AINP)
unnamed: C38.2, R8.1, R10.2, U10.1 (OUT)
POT_I2C_SCL: U19.5 (SCL), U21.5 (SCL), U22.5 (SCL)
POT_I2C_SDA: U19.4 (SDA), U21.4 (SDA), U22.4 (SDA)
PWR_ANA_3V3: C3.2, C18.2, C23.2, U3.6 (AVDD), U7.6 (AVDD), U9.6 (AVDD)
PWR_ANA_5V: C6.2, C21.2, C34.2, C53.2, C55.2, C57.2, U6.5 (V+), U6.6 (V+), U8.5 (V+), U8.6 (V+), U10.5 (V+), U10.6 (V+), U19.8 (VDD), U21.8 (VDD), U22.8 (VDD)
PWR_ANA_10V: FB1.1
PWR_SYS_3V3: C4.2, C19.2, C24.2, C52.2, C54.2, C56.2, U3.4 (DVDD), U7.4 (DVDD), U9.4 (DVDD), U19.2 (A0), U19.6 (VIO), U21.6 (VIO), U22.3 (A1), U22.6 (VIO)
SEN_OFFSET_OS1: U10.3 (+)
SEN_OFFSET_OS2: U8.3 (+)
SEN_OFFSET_OS3: U6.3 (+)
SEN_SIG_OS1: R9.1, U1.21 (OS1)
SEN_SIG_OS2: R6.1, U1.22 (OS2)
SEN_SIG_OS3: R2.1, U1.1 (OS3)

Notes on the sheet:
UNCONTROLLED WHEN PRINTED

Schematic: sensor.sch, sheet 3, POWER

Parts:
C8: 100uF 50V; 8MM_RADIAL_3.5MM_PITCH
C9, C10: 0.1uF 50V; 0603
C11: 100pF 50V; 0603
FB2: 600R; 0603
Q2: KSC2690A; TO126V
R3: 10k; 0603
R11: 20k; 0603

Connections:
GND: C8.N (K), C9.1, C10.1, C11.1, R11.1; also elsewhere on the board
unnamed: C9.2, C11.2, FB2.2, Q2.2 (C), R3.2
unnamed: C8.P (A), Q2.3 (B), R3.1, R11.2
PWR_SENS_UNREG: C10.2, Q2.1 (E)

Notes on the sheet:
UNCONTROLLED WHEN PRINTED

Board: 4 copper layers, 50.0 x 151.0 mm, 72 parts (2 on the bottom side), 39 nets.

Other parts of the board:
MECH5, MECH6, MECH7, MECH8: 6mm x 3mm; MOUNTHOLE_6X3

## EAGLE design led copy.brd

Board: 4 copper layers, 28.0 x 67.0 mm, 33 parts (0 on the bottom side), 23 nets, no tracks yet.

Parts:
C1, C2: 0.1uF 50V; 0603
C3: 1uF 50V; 1206
C4: 2.2uF 10V; 0603
CN1: JST GH 10 Pin; 1.25-10PWT
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12: 5000K; LH502C
MECH1, MECH2, MECH3, MECH4: 6mm x 3mm; MOUNTHOLE_6X3
Q1: FDD5612; TO252
R1, R2, R7, R8: 1R; 1206
R3: 0.33R; 0603
R4: 100R; 0603
R5: 20k; 0603
R6: 10k; 0603
TH1: 10k 4037k; 0603
U1: NCS20071; SOT23-5
U2: TPS70950; SOT23-5

Connections:
GND: C1.1, C2.1, C3.1, C4.1, CN1.4, CN1.5, CN1.6, CN1.7, R3.1, R6.1, U1.2, U2.2
LED_PWM_CONT: CN1.8, R5.1
unnamed: D1.K, D2.A
unnamed: D2.K, D3.A
unnamed: D7.K, D8.A
unnamed: D4.K, D5.A
unnamed: D5.K, D6.A
unnamed: D4.A, R2.1
unnamed: D8.K, D9.A
unnamed: D10.A, R7.1
unnamed: D7.A, R8.1
unnamed: D11.K, D12.A
unnamed: D10.K, D11.A
unnamed: D1.A, R1.1
unnamed: D3.K, D6.K, D9.K, D12.K, Q1.2
unnamed: C1.2, R5.2, R6.2, U1.3
unnamed: Q1.1, R4.2
unnamed: R4.1, U1.1
unnamed: Q1.3, R3.2, U1.4
unnamed: C2.2, C4.2, U1.5, U2.5
PWR_LED_24V: C3.2, CN1.1, CN1.2, CN1.3, R1.2, R2.2, R7.2, R8.2, U2.1, U2.3
TEMP_SEN_A: CN1.9, TH1.2
TEMP_SEN_B: CN1.10, TH1.1

## Commit log

2023-08-02 Revision 1.0.0
2023-12-18 LED PCB designewd
2023-12-24 main board architectre
2024-01-06 Progress
2024-01-11 Smaller form factor
2024-01-12 gain through digiport implemented
2024-01-22 Controller nearly done
2024-01-24 Controller nearly complete
2024-02-04 Control and sensor merged into main
2024-02-18 FTDI and CCD routed
2024-02-18 Board routed, needs motor driver and thorough review
2024-02-19 Progress, motor controller remaining
2024-02-24 Bits and pieces
2024-03-10 New LED PCB formfactor. UART debug added to FPGA for softcore.
2024-03-10 Cleared errors on PCB
2024-03-15 New formactor
2024-03-16 Progression
2024-03-16 Initial layout done
2024-03-16 DRC errors processed
2024-03-17 New LED driver PCB
2024-03-18 New LED layout
2024-03-29 Moving back to Trion
2024-04-01 Passes DRC
2024-04-06 Bidirectional motor controller added
2024-04-06 MIPI length matched
2024-04-14 ESP32 added with architecture implemented. First attempt.
2024-04-14 LEDs routed. Text added. Pushed to Fusion
2024-04-14 DRC compelte. Top and bottom copper fill. Pushed to Fusion
2024-04-16 Updated release dates
2024-04-16 Source removed for merge
2024-04-16 All designs pushed to fusion
2024-04-16 Stepper motor driver wired in
2024-04-16 DRC passes
2024-04-16 Idents updated, DRC check again
2024-04-22 Voltage level translator fixed
2024-04-24 Tidied up schematic
2024-04-24 Designed FT2232H MINI MODULE adapter
