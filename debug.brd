# Repository gswdh/FilmScannerElectronics

## EAGLE design main.brd

Notes on the sheet:
2024.04.16 - GSWDH LTD. FILM SCANNER MAIN REVISION 3.0.0 DESIGN BY GEORGE WALLER AT GSWDH LTD. GEORGEWALLER@GSWDH.CO.UK CONFIDENTIAL. FOR THE INTENDED READER ONLY.
UNCONTROLLED WHEN PRINTED

Parts:
C25, C64, C65, C67, C72, C73, C74, C75, C76, C78, C79, C82, C83: 0.1uF 16V; 0402
C36, C37, C62, C63, C71, C77, C80, C84: 10uF 6.3V; 0402
C39: 150pF 25V; 0402
C49: 1uF 10V; 0402
C162, C163: 0.1uF 10V; 0402
C164: 10uF 10V; 0603
CN8: FFC 8P 0.5mm; HC-FPC-05-09-8RLTAG
D5, D6, D7: RED LED; 0603_POLAR
L3: 1uH; 1008
OSC1: 33MHz; KC2016Z
R3, R29, R34: 22R; 0402
R21: 51k; 0402
R25: 24k; 0402
R26, R35, R36, R37, R76, R77, R87, R89, R90, R129, R140, R141, R143, R146, R147: 10k; 0402
R27: 100R; 0402
R59, R79, R80: 2.2k; 0402
R148: 36k; 0402
R149: 62k; 0402
U1: T20F169; FBGA169
U5: TPS62065; WSON8
U11: AP7335; DFN2020-6
U13: W958D8NBYA5I; VBGA24
U15: ESP32; ESP32-WROOM-32D

Connections:
AR_CLK: U1.F3 (GPIOL_72_EXTFB0_CDI14); also elsewhere on the board
AR_GPIO0: U1.C1 (GPIOL_73_EXTFB1_CDI15); also elsewhere on the board
AR_GPIO1: U1.C2 (GPIOL_71_NSTATUS); also elsewhere on the board
AR_GPIO2: U1.D1 (GPIOL_69_CBSEL1); also elsewhere on the board
AR_GPIO3: U1.D2 (GPIOL_70_CBSEL0); also elsewhere on the board
AR_MIPI_CLK_N: U1.B12 (MIPI1_RXDP2); also elsewhere on the board
AR_MIPI_CLK_P: U1.A12 (MIPI1_RXDN2); also elsewhere on the board
AR_MIPI_D0_N: U1.C10 (MIPI1_RXDP1); also elsewhere on the board
AR_MIPI_D0_P: U1.D10 (MIPI1_RXDN1); also elsewhere on the board
AR_MIPI_D1_N: U1.A11 (MIPI1_RXDN0); also elsewhere on the board
AR_MIPI_D1_P: U1.B11 (MIPI1_RXDP0); also elsewhere on the board
AR_MIPI_D2_N: U1.C13 (MIPI1_RXDP4); also elsewhere on the board
AR_MIPI_D2_P: U1.B13 (MIPI1_RXDN4); also elsewhere on the board
AR_MIPI_D3_N: U1.D12 (MIPI1_RXDN3); also elsewhere on the board
AR_MIPI_D3_P: U1.C12 (MIPI1_RXDP3); also elsewhere on the board
AR_NRESET: U1.E3 (GPIOL_74_PLLIN0); also elsewhere on the board
AR_XSHUTDOWN: U1.B1 (GPIOL_75_PLLIN1); also elsewhere on the board
ESP_EN: C162.2, R87.1, U15.3 (EN); also elsewhere on the board
ESP_I2C_SCL: U15.9 (IO33); also elsewhere on the board
ESP_I2C_SDA: U15.8 (IO32); also elsewhere on the board
ESP_IO0: R29.1, R89.1, U15.25 (IO0); also elsewhere on the board
ESP_LED_0: R79.2, U15.36 (IO22)
ESP_LED_1: R59.2, U15.37 (IO23)
ESP_UART_RX: R90.1, U15.34 (RXD0); also elsewhere on the board
ESP_UART_TX: U15.35 (TXD0); also elsewhere on the board
FLS_SPI_CLK: U1.K1 (GPIOL_01_CCK), U15.13 (IO14)
FLS_SPI_MISO: U1.J2 (GPIOL_09_CDI1), U15.12 (IO27)
FLS_SPI_MOSI: U1.J1 (GPIOL_08_CDI0), U15.11 (IO26)
FLS_SPI_NCS: R36.2, U1.L1 (GPIOL_00_SS_N), U15.14 (IO12)
FPGA_CLK33M: R3.2, U1.J12 (GPIOR_157_PLLIN)
FPGA_CONF_CBUS_0: R141.1, U1.J11 (GPIOR_151_CBUS0)
FPGA_CONF_CBUS_1: R140.1, U1.G13 (GPIOR_150_CBUS1)
FPGA_CONF_CDONE: R147.1, U1.L2 (CDONE), U15.6 (IO34)
FPGA_CONF_NCRST: CN8.7, R146.1, U1.K3 (CRESET_N), U15.10 (IO25)
FPGA_CONF_NTEST: R143.1, U1.H12 (GPIOR_158_TEST_N)
FPGA_JTAG_TCK: CN8.4, R76.1, U1.H1 (TCK)
FPGA_JTAG_TDI: CN8.5, U1.J3 (TDI)
FPGA_JTAG_TDO: CN8.2, R77.1, U1.G1 (TDO)
FPGA_JTAG_TMS: CN8.3, U1.H2 (TMS)
FPGA_LED_0: R80.2, U1.F13 (GPIOR_119_CTRL12)
FPGA_LOGIC_NRST: R29.2, U1.E13 (GPIOR_78_EXTFB0_CDI31)
FT_CLKOUT: U1.M13 (GPIOB_CLKP0); also elsewhere on the board
FT_D0: U1.M12 (GPIOB_RXN09); also elsewhere on the board
FT_D1: U1.N12 (GPIOB_RXN10); also elsewhere on the board
FT_D2: U1.M11 (GPIOB_RXP09); also elsewhere on the board
FT_D3: U1.N11 (GPIOB_RXP10); also elsewhere on the board
FT_D4: U1.M10 (GPIOB_RXN07); also elsewhere on the board
FT_D5: U1.N10 (GPIOB_RXP07); also elsewhere on the board
FT_D6: U1.M9 (GPIOB_RXP05); also elsewhere on the board
FT_D7: U1.N9 (GPIOB_RXN05); also elsewhere on the board
FT_NOE: U1.L7 (GPIOB_RXP00); also elsewhere on the board
FT_NRD: U1.N8 (GPIOB_RXN03); also elsewhere on the board
FT_NRST: U1.L11 (GPIOB_RXN08); also elsewhere on the board
FT_NRXF: U1.L8 (GPIOB_RXP02); also elsewhere on the board
FT_NSIWU: U1.N7 (GPIOB_RXP01); also elsewhere on the board
FT_NTXE: U1.M8 (GPIOB_RXP03); also elsewhere on the board
FT_NWR: U1.M7 (GPIOB_RXN01); also elsewhere on the board
GND: C25.1, C36.1, C37.1, C49.1, C62.1, C63.1, C64.1, C65.1, C67.1, C71.1, C72.1, C73.1, C74.1, C75.1, C76.1, C77.1, C78.1, C79.1, C80.1, C82.1, C83.1, C84.1, C162.1, C163.1, C164.1, CN8.1, D5.K, D6.K, D7.K, OSC1.2 (GND), R25.1, R26.2, R35.1, R36.1, R149.1, U1.A1 (GND), U1.A13 (GND), U1.C11 (GNDA_MIPI), U1.D3 (GNDA_MIPI), U1.D11 (GNDA_MIPI), U1.E2 (GND), U1.E5 (GNDA_MIPI), U1.E12 (GND), U1.F5 (GND), U1.F6 (GND), U1.F8 (GND), U1.G6 (GND), U1.G7 (GND), U1.J7 (GND), U1.J8 (GND), U1.K2 (GND), U1.K12 (GND), U1.L12 (GND), U1.M4 (GND), U1.N1 (GND), U1.N13 (GND), U5.1 (GND), U5.3 (GND), U5.6 (MODE), U5.PAD (GND), U11.2 (GND), U11.7 (GND), U13.B3 (VSS), U13.C1 (VSSQ), U13.E5 (VSSQ), U15.1 (GND), U15.15 (GND), U15.38 (GND), U15.39 (GND); also elsewhere on the board
LED_PWM_CONT: U15.27 (IO16); also elsewhere on the board
MTR_DIR: R35.2, U15.24 (IO2); also elsewhere on the board
MTR_MS1: U15.31 (IO19); also elsewhere on the board
MTR_MS2: U15.30 (IO18); also elsewhere on the board
MTR_NEN: U15.33 (IO21); also elsewhere on the board
MTR_STP: U15.26 (IO4); also elsewhere on the board
MTR_UART_BIDIR: R34.1, U15.28 (IO17); also elsewhere on the board
MTR_UART_TX: R34.2, R129.1, U15.29 (IO5)
unnamed: L3.1, U5.2 (SW)
unnamed: C39.1, R148.1, R149.2, U5.4 (FB)
unnamed: OSC1.3 (OUT), R3.1
unnamed: R37.1, U15.23 (IO15)
unnamed: R21.1, R25.2, U11.6 (FB)
unnamed: R26.1, U1.N4 (REF_RES)
unnamed: D6.A, R59.1
unnamed: D7.A, R79.1
unnamed: D5.A, R80.1
PWR_FPGA_1V2: C37.2, C39.2, C71.2, C72.2, C73.2, C74.2, C75.2, C76.2, L3.2, R148.2, U1.C3 (VCC12A_MIPI0_TX), U1.E4 (VCC), U1.E6 (VCC12A_MIPI0_RX), U1.E8 (VCC12A_MIPI1_TX), U1.E10 (VCC12A_MIPI1_RX), U1.F7 (VCC), U1.F9 (VCC), U1.G4 (VCCA_TL), U1.G5 (VCC), U1.G8 (VCC), U1.G9 (VCC), U1.G10 (VCCA_TR), U1.H6 (VCC), U1.J6 (VCC), U1.J10 (VCCA_BR)
PWR_FPGA_2V5: C62.2, C82.2, R21.2, U1.E7 (VCC25A_MIPI0), U1.E9 (VCC25A_MIPI1), U11.4 (VOUT)
PWR_SYS_1V8: C63.2, C64.2, C65.2, C67.2, C83.2, C84.2, U1.F4 (VCCIO1E), U1.H4 (VCCIO1B_1C_1D), U1.H5 (VCCIO4B), U1.J5 (VCCIO4B), U13.B4 (VCC), U13.D1 (VCCQ), U13.E4 (VCCQ); also elsewhere on the board
PWR_SYS_3V3: C25.2, C36.2, C49.2, C77.2, C78.2, C79.2, C80.2, C163.2, C164.2, CN8.8, OSC1.1 (!ST), OSC1.4 (VCC), R37.2, R76.2, R77.2, R87.2, R89.2, R90.2, R129.2, R140.2, R141.2, R143.2, R146.2, R147.2, U1.F10 (VCCIO3A_3B), U1.H7 (VCCIO4A), U1.H8 (VCCIO4A), U1.H9 (VCCIO4A), U1.H10 (VCCIO3C_3D_3E), U1.J4 (VCCIO1A), U1.J9 (VCCIO4A), U5.5 (EN), U5.7 (VIN), U5.8 (VIN), U11.1 (ON), U11.3 (VIN), U15.2 (3V3); also elsewhere on the board
RAM_CLK_N: R27.1, U1.M1 (GPIOB_TXN01), U13.B1 (!CLK)
RAM_CLK_P: R27.2, U1.M2 (GPIOB_TXP01), U13.B2 (CLK)
RAM_D0: U1.N6 (GPIOB_TXP08), U13.D3 (D0)
RAM_D1: U1.K5 (GPIOB_TXP06), U13.D2 (D1)
RAM_D2: U1.M6 (GPIOB_TXN08), U13.C4 (D2)
RAM_D3: U1.L6 (GPIOB_TXN09), U13.D4 (D3)
RAM_D4: U1.K6 (GPIOB_TXP09), U13.D5 (D4)
RAM_D5: U1.N5 (GPIOB_TXP05), U13.E3 (D5)
RAM_D6: U1.M3 (GPIOB_TXP02), U13.E2 (D6)
RAM_D7: U1.L4 (GPIOB_TXN03), U13.E1 (D7)
RAM_NCS: U1.L3 (GPIOB_TXN02), U13.A3 (!CS)
RAM_NRST: U1.K4 (GPIOB_TXP03), U13.A4 (!RESET)
RAM_RWDS: U1.L5 (GPIOB_TXN06), U13.C3 (RWDS)
SIG_PWR_BUS_UNREG: U15.16 (IO13); also elsewhere on the board

Notes on the sheet:
UNCONTROLLED WHEN PRINTED
